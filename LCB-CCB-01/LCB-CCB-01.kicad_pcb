# Repository upb-lea/LCB-CCB-01_LEA_Control_Board

File README.md:

# LEA Control Board

The LEA Control Board (LCB) is a construction kit to provide power electronic converters with a control board.

The basic module is the control board (LCB-CCB) itself. It contains a powerful dual-core processor, error latches and various predefined low-pass filters to respond to input signals. An XDS100v2 debugger is directly integrated on the board. 

The docking board (LCB-CDB) is suitable for initial operation. This contains various input options (switches, buttons, potentiometers) as well as LEDs for output.

The external hardware monitor (LCB-CHW) is for viewing internal counter variables on the oscilloscope and is mainly used for troubleshooting the control board in the overall system (control board + power converter).

The pin board (LCB-CPB) is for in-circuit signal measurments by an external scope on certain pins.
The test board (LCB-CTB) was developed to check all pins, PWM signals, ADCs and DACs for functionality after a new board has been completed (end of line test).

## PCB overview
This is the main repository of the LEA Control Board (LCB) project. Due to correct PCB versioning, every single PCB is in its own repository.
 * [LCB-CDB-01_Dock_Board](https://github.com/upb-lea/LCB-CDB-01_Dock_Board)
 * [LCB-CHW-01_Hardware_Monitor](https://github.com/upb-lea/LCB-CHW-01_Hardware_Monitor)
 * [LCB-CPB-01_Pin_Board](https://github.com/upb-lea/LCB-CPB-01_Pin_Board)
 * [LCB-CTB-01_Test_Board](https://github.com/upb-lea/LCB-CTB-01_Test_Board)
 * [LCB-CBB-01_Bus_Board](https://github.com/upb-lea/LCB-CBB-01_Bus_Board)

Symbols, footprints and 3D-models can be found in the [LEA KiCad Library](https://github.com/upb-lea/LEA_KiCad_Library).

## PCB versioning
Example `LCB-CCB-01-1.0.5`:
 * First three letters `LCB`: Parent project name `LEA Control Board`
 * Second three letters `CCB`: PCB name `Control Board`
 * Number `01`: PCB size. For future use in case of several PCB sizes
 * First version number `1`: Major version, increases for incompatible changes
 * Second number `0`: PCB release, increases for improved layouts
 * Third number `5`: Schematic version, increases for component changes, but no layout changes

## Kicad Options
To open the LEA Control Board files, [KiCad 9](https://www.kicad.org/) needs to be used. Make sure that you run the latest version of KiCad.

### Downloading this project and folder structure
To use this project, LEA KiCad symbols, footprints and 3D-models need to be included. Note, that both folders need to be in the same direction.

Clone the symbols, footprints and 3D-models:
```
git clone https://github.com/upb-lea/LEA_KiCad_Library.git
```

Clone this project:
```
https://github.com/upb-lea/LCB-CCB-01_LEA_Control_Board.git
```
If you are downloading the `.zip`-files manually, unpack them in the same direction.

### Symbol library and footprint libary
The libraries are included by default, if the above mentioned folder structure was considered. Open Kicad, load one of the projects and see the libraries:
 * `symbol editor` -> Search for `LEA_Symbol_Library`
 * `footprint editor` -> Search for `LEA_Footprint_Library`

### Set environment variable for 3D models:

Please refer to [this section](https://github.com/upb-lea/LEA_KiCad_Library#set-environment-variable-for-3d-models).

## Software
Various software examples using the LEA Control Board is available and can be found [in this repository](https://github.com/upb-lea/LCB-Software). There are examples for using the hardware monitor, SPI, UART and many others.

## How to design the LCB into your cirucit?
 * A stable external 3.3 V power supply must be provided, recommended by a linear regulator.
 * It is recommended to use buffer-ICs for the LCB GPIOs to prevent damage on the LCB board.

## Design decisions 
 * To not confuse the user, there is only one supply voltage needed. All pins of the board are save for 3.3 V. Some components can be used with higher voltage, but this would lead to confusion and may damage the board due to misunderstandings.
 * A stable external 3.3 V power supply must be provided, recommended by a linear regulator. We did not decide for an internal regulator, as this regulator does not know your external load, and might be overloaded.

## KiCad design LCB-CCB-01/LCB-CCB-01.kicad_pcb

Parts:
ACCESSORY901: ACCESSORY_USB_C_cable; mouser# 474-CAB-15424
O901, O902, O903, O904, O905, O906, O907, O908, O909, O910, O911, O912: Fiducial_medium; Fiducials_medium
SYM901, SYM902: SYM_LEA_Logo; SYM_lea_logo

Notes on the sheet:
Components reference: 2XX -> Page 2 3XX -> Page 3 4XX -> Page 4 5XX -> Page 5 6XX -> Page 6 7XX -> Page 7 8XX -> Page 8 9XX -> Page 9 1XXX -> Page 10
https://github.com/upb-lea/LEA_control_board

Parts:
C201, C205, C207, C216: 4u7; C_0603; mouser# 810-C1608X5R1V475K
C202, C203: 10n; C_0603; mouser# 810-CGA3E2X7R1H103K
C204: 1u0; C_0603; mouser# 810-C1608X5R1H105K
C206, C208, C209, C210, C211, C212, C213, C214, C215, C217, C218, C219, C220, C221, C222, C223: 100n; C_0603; mouser# 810-C1608X5R1H104K
D201: 2mA; LED_0603_G; mouser# 604-APTD1608LCGCK
D202: 1A0; SOD-323_Infineon; mouser# 726-BAS3010A-03WE6
D203, D204: 2mA; LED_0603_B; mouser# 604-APHD1608LVBCD
H201: M3_MountingHole; MountingHole_M3
J201: USBC_GTC_USB4110-GF-A; USB_C_GCT_USB4110-GF-A; mouser# 640-USB4110-GF-A
J202: FTR-110-03-G-D-06-TR; FTR-110-03-G-D-06; mouser# 200-FTR11003GD06TR
L201, L202: Ferrite_0603; L_0603; mouser# 530-FCB-0603-601A
R201, R205, R207, R208, R211, R223: 2k2; R_0603; mouser# 71-CRCW06032K20FKEAC
R202, R213, R214: 680R; R_0603; mouser# 71-CRCW0603680RFKEAC
R203, R204, R220, R221, R224: 4k7; R_0603; mouser# 71-CRCW06034K70FKEBC
R206, R209, R222: 0R0; R_0603; mouser# 71-CRCW06030000Z0EAC
R210: 10k; R_0603; mouser# 71-CRCW060310K0FKEAC
R217: 12k; R_0603; mouser# 71-CRCW060312K0FKEAC
S201: CAS-120TA; mouser# 229-CAS-120TA
U201: FT2232HL; LQFP-64_12x12_Pitch0.5mm_FTDI; mouser# 895-FT2232HL-TRAY
U202: 93LC56BT-I_OT; SOT-23-6_Microchip; mouser# 579-93LC56BT-I/OT
U203: MIC5259-3.3YD5-TR; SOT-23-5_Microchip; mouser# 998-MIC5259-3.3YD5TR
U204, U205, U206: ADG736BRMZ; MSOP10_AnalogDevices; mouser# 584-ADG736BRMZ
Y201: ECS-2033-120-AU; Osc_ECS_2.5x2; mouser# 520-2033-120-AU

Connections:
+1.8V_HV: C216.1, C217.1, C218.1, C219.1, C220.1, U201.12 (VCORE), U201.37 (VCORE), U201.49 (VREGOUT), U201.64 (VCORE)
+3.3V_LV: C204.1, C209.1, C210.1, C211.1, C212.1, C213.1, C214.1, C215.1, C221.1, C222.1, C223.1, D201.A, D203.A, D204.A, L201.2, L202.2, R201.1, R205.2, R207.1, R210.2, R220.2, R221.1, R224.1, S201.1, U201.20 (VCCIO), U201.31 (VCCIO), U201.42 (VCCIO), U201.50 (VREGIN), U201.56 (VCCIO), U202.6 (VCC), U203.5 (Vout), U204.8 (VDD), U205.8 (VDD), U206.8 (VDD), Y201.1 (Tri-State), Y201.4 (Vdd); also elsewhere on the board
+5V_LV: C201.1, C202.1, D202.C, U203.1 (Vin), U203.3 (EN)
/XDS100 - Page 2/CC1: J201.A5 (CC1), R203.2
/XDS100 - Page 2/CC2: J201.B5 (CC2), R204.1
/XDS100 - Page 2/CLK_12MHz: U201.2 (OSCI), Y201.3 (Output)
/XDS100 - Page 2/D+: J201.A6 (Dp1), J201.B6 (Dp2), U201.8 (DP)
/XDS100 - Page 2/D-: J201.A7 (Dn1), J201.B7 (Dn2), U201.7 (DM)
/XDS100 - Page 2/Debug_Select: S201.2, U204.1 (IN1), U204.5 (IN2), U205.1 (IN1), U205.5 (IN2), U206.1 (IN1), U206.5 (IN2)
/XDS100 - Page 2/EE_CLK: U201.62 (EECLK), U202.4 (CLK)
/XDS100 - Page 2/EE_CS: U201.63 (EECS), U202.5 (CS)
/XDS100 - Page 2/EE_Data: R211.2, U201.61 (EEDATA), U202.3 (DI)
/XDS100 - Page 2/EXT_TCK: J202.11, R222.1, U205.7 (S2B)
/XDS100 - Page 2/EXT_TDI: J202.3, U205.9 (S1B)
/XDS100 - Page 2/EXT_TDO: J202.7, U206.7 (S2B)
/XDS100 - Page 2/EXT_TMS: J202.1, U204.9 (S1B)
/XDS100 - Page 2/EXT_TRST: J202.2, U204.7 (S2B)
/XDS100 - Page 2/LED54: R213.2, U201.54 (BCBUS3)
/XDS100 - Page 2/LED55: R214.2, U201.55 (BCBUS4)
/XDS100 - Page 2/REF: R217.2, U201.6 (REF)
/XDS100 - Page 2/RESET: R205.1, U201.14 (RESET#)
/XDS100 - Page 2/Shield: J201.S (Shield), R209.2
/XDS100 - Page 2/VBUS: D202.A, J201.A4B9 (VBUS), J201.B4A9 (VBUS)
/XDS100 - Page 2/VPHY: C205.1, C206.1, L202.1, U201.4 (VPHY)
/XDS100 - Page 2/VPLL: C207.1, C208.1, L201.1, U201.9 (VPLL)
/XDS100 - Page 2/XDS100_TCK: R206.1, U201.16 (ADBUS0), U205.4 (S2A)
/XDS100 - Page 2/XDS100_TDI: U201.17 (ADBUS1), U205.2 (S1A)
/XDS100 - Page 2/XDS100_TDO: U201.18 (ADBUS2), U206.4 (S2A)
/XDS100 - Page 2/XDS100_TMS: U201.19 (ADBUS3), U204.2 (S1A)
/XDS100 - Page 2/XDS100_TRST: U201.21 (ADBUS4), U204.4 (S2A)
GND_LV: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, J201.A1B12 (GND), J201.B1A12 (GND), J202.4, J202.8, J202.10, J202.12, J202.16, J202.17, J202.18, J202.19, J202.20, R202.1, R203.1, R204.2, R208.1, R209.1, R217.1, R223.2, S201.3, U201.1 (GND), U201.5 (GND), U201.10 (AGND), U201.11 (GND), U201.13 (TEST), U201.15 (GND), U201.25 (GND), U201.35 (GND), U201.47 (GND), U201.51 (GND), U202.2 (VSS), U203.2 (GND), U204.3 (GND), U205.3 (GND), U206.3 (GND), Y201.2 (Gnd); also elsewhere on the board
unnamed: D201.C, R202.2
unnamed: D203.C, R213.1
unnamed: D204.C, R214.1
unnamed: J202.5, R224.2
unnamed: J202.9, R222.2
unnamed: J202.13, R220.1
unnamed: J202.14, R221.2
unnamed: R207.2, U201.28 (ACBUS2)
unnamed: R208.2, U201.32 (ACBUS5)
unnamed: R206.2, U201.24 (ADBUS7)
unnamed: U201.40 (BDBUS2), U201.41 (BDBUS3)
unnamed: R210.1, R211.1, U202.1 (DO)
unnamed: C203.1, U203.4 (BYP)
SCIA_RX_LV: U201.39 (BDBUS1); also elsewhere on the board
SCIA_TX_LV: U201.38 (BDBUS0); also elsewhere on the board
TCK_LV: U205.6 (D2); also elsewhere on the board
TDI_LV: U205.10 (D1); also elsewhere on the board
TDO_LV: U206.6 (D2); also elsewhere on the board
TMS_LV: R201.2, U204.10 (D1); also elsewhere on the board
TRST_LV: R223.1, U204.6 (D2); also elsewhere on the board

Notes on the sheet:
Power Status LED
EEPROM XDS100
Decoupling Capacitors MCU FT2232HL
Debugger Selection
External Debugger
XDS100 USB-C Port
FTDI2232HL XDS100 MCU
12 MHz Clock
LDO 3.3V

Parts:
C301, C304, C305, C308: 2u2; C_0603; mouser# 810-C1608X5R1V225K
C302, C303, C306, C307: 100n; C_0603; mouser# 810-C1608X5R1H104K
R301, R302: 0R0; R_0603; mouser# 71-CRCW06030000Z0EAC
S301: CAS-120TA; mouser# 229-CAS-120TA
U301, U302: ISO_ISO7741FQDWWQ1; SOIC-16_TI_DWW0016A_Optimized; mouser# 595-ISO7741FQDWWQ1

Connections:
+3.3V_HV: R301.1, R302.1, S301.1; also elsewhere on the board
+3.3V_LV: C301.1, C302.1, C305.1, C306.1, U301.1 (VCC1), U301.7 (EN1), U302.1 (VCC1), U302.7 (EN1); also elsewhere on the board
/Isolation - Page 3/Enable_Output: S301.2, U301.10 (EN2), U302.10 (EN2)
GND_HV: C303.2, C304.2, C307.2, C308.2, S301.3, U301.9 (GND2), U301.15 (GND2), U302.9 (GND2), U302.15 (GND2); also elsewhere on the board
GND_LV: C301.2, C302.2, C305.2, C306.2, U301.2 (GND1), U301.8 (GND1), U302.2 (GND1), U302.5 (INC), U302.8 (GND1); also elsewhere on the board
unnamed: C303.1, C304.1, R301.2, U301.16 (VCC2)
unnamed: C307.1, C308.1, R302.2, U302.16 (VCC2)
SCIA_RX_HV: U302.14 (OUTA); also elsewhere on the board
SCIA_RX_LV: U302.6 (OUTD); also elsewhere on the board
SCIA_TX_HV: U302.11 (IND); also elsewhere on the board
SCIA_TX_LV: U302.3 (INA); also elsewhere on the board
TCK_HV: U301.12 (OUTC); also elsewhere on the board
TCK_LV: U301.5 (INC); also elsewhere on the board
TDI_HV: U301.13 (OUTB); also elsewhere on the board
TDI_LV: U301.4 (INB); also elsewhere on the board
TDO_HV: U301.11 (IND); also elsewhere on the board
TDO_LV: U301.6 (OUTD); also elsewhere on the board
TMS_HV: U301.14 (OUTA); also elsewhere on the board
TMS_LV: U301.3 (INA); also elsewhere on the board
TRST_HV: U302.13 (OUTB); also elsewhere on the board
TRST_LV: U302.4 (INB); also elsewhere on the board

Notes on the sheet:
JTAG and SCI Isolation
Enable/Disable Debugger

Parts:
C701, C703, C704, C705, C708, C709, C712, C715, C717, C721, C724, C725, C728, C729: 100n; C_0603; mouser# 810-C1608X5R1H104K
C702: 10n; C_0603; mouser# 810-CGA3E2X7R1H103K
C706, C707, C710, C711, C713, C714, C716, C718, C719, C720, C722, C723, C726, C727, C730: 100n; C_0402; mouser# 810-C1005X7R1H104K
C740, C741: 1u0; C_0603; mouser# 810-C1608X5R1H105K
R701, R702, R703, R705, R706: 2k2; R_0603; mouser# 71-CRCW06032K20FKEAC
R704, R712, R713, R714: 0R0; R_0603; mouser# 71-CRCW06030000Z0EAC
R707, R708, R709, R710: 33R; R_0603; mouser# 71-CRCW060333R0FKEAC
R711: 56R; R_0603; mouser# 71-CRCW060356R0FKEAC
R715: 10R; R_0603; mouser# 71-CRCW060310R0FKEAC
SW701: SW_Push_RightAngle; Sw_Push_RightAngle; mouser# 653-B3U-3000PM
U701: TPS3702CX33DDCT; TSOT-23-6_TI; mouser# 595-TPS3702CX33DDCT
U702: TPS3702CX12DDCT; TSOT-23-6_TI; mouser# 595-TPS3702CX12DDCT
U703: TMS320F28388D; BGA-361_19x19_16.0x16.0mm; mouser# 595-F28388DZWTSR
U704: PI6C49CB04AQ3WEX; SOIC-8; mouser# 621-PI6C49CB04AQ3WEX
Y701: ECS-2520S33-250-FN-TR; Osc_ECS_2.5x2; mouser# 520-2520S33-250-FNT

Connections:
+1.2V_HV: C708.1, C709.1, C710.1, C711.1, C712.1, C713.1, C714.1, R711.1, U702.3 (SENSE), U703.E9 (VDD), U703.E11 (VDD), U703.F9 (VDD), U703.F11 (VDD), U703.G14 (VDD), U703.G15 (VDD), U703.J14 (VDD), U703.J15 (VDD), U703.K5 (VDD), U703.K6 (VDD), U703.P10 (VDD), U703.P13 (VDD), U703.R10 (VDD), U703.R13 (VDD); also elsewhere on the board
+3.3V_HV: C706.1, C707.1, C715.1, C716.1, C717.1, C718.1, C719.1, C720.1, C721.1, C722.1, C723.1, C724.1, C725.1, C726.1, C727.1, C728.1, C729.1, C730.1, R701.2, R702.2, R703.1, R705.1, R712.1, R713.1, R714.1, U703.A9 (VDDIO), U703.A18 (VDDIO), U703.B1 (VDDIO), U703.E7 (VDDIO), U703.E10 (VDDIO), U703.E13 (VDDIO), U703.E16 (VDDIO), U703.F4 (VDDIO), U703.F7 (VDDIO), U703.F10 (VDDIO), U703.F13 (VDDIO), U703.F16 (VDDIO), U703.G4 (VDDIO), U703.G5 (VDDIO), U703.G6 (VDDIO), U703.H5 (VDDIO), U703.H6 (VDDIO), U703.H16 (VDDOSC), U703.H17 (VDDOSC), U703.L14 (VDDIO), U703.L15 (VDDIO), U703.M1 (VDDIO), U703.M5 (VDDIO), U703.M6 (VDDIO), U703.N14 (VDDIO), U703.N15 (VDDIO), U703.P6 (VDDA), U703.P9 (VDDIO), U703.R6 (VDDA), U703.R9 (VDDIO), U703.R11 (VDD3VFL), U703.R12 (VDD3VFL), U703.V19 (VDDIO), U703.W8 (VDDIO); also elsewhere on the board
/MCU - Page 7/25MHz_CLK: U704.1 (CLK), Y701.3 (Output)
/MCU - Page 7/CLK_F283XX_25MHz: R707.1, U703.G19 (X1)
/MCU - Page 7/MCU_XRSn: C702.1, R703.2, R704.2, R715.2, U703.F19 (XRSn)
ENET_CLK_25MHz: R710.1; also elsewhere on the board
ESC_TX0_ENA|GPIO84: C741.1, R702.1; also elsewhere on the board
ESC_TX1_DATA3|GPIO72: C740.1, R701.1; also elsewhere on the board
GND_HV: C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, C708.2, C709.2, C710.2, C711.2, C712.2, C713.2, C714.2, C715.2, C716.2, C717.2, C718.2, C719.2, C720.2, C721.2, C722.2, C723.2, C724.2, C725.2, C726.2, C727.2, C728.2, C729.2, C730.2, C740.2, C741.2, R706.2, R711.2, SW701.1, U701.2 (GND), U702.2 (GND), U703.A1 (VSS), U703.A10 (VSS), U703.A19 (VSS), U703.E5 (VSS), U703.E6 (VSS), U703.E8 (VSS), U703.E12 (VSS), U703.E14 (VSS), U703.E15 (VSS), U703.F5 (VSS), U703.F6 (VSS), U703.F8 (VSS), U703.F12 (VSS), U703.F14 (VSS), U703.F15 (VSS), U703.G16 (VSS), U703.G17 (VSS), U703.H8 (VSS), U703.H9 (VSS), U703.H10 (VSS), U703.H11 (VSS), U703.H12 (VSS), U703.H14 (VSS), U703.H15 (VSS), U703.H18 (VSSOSC), U703.H19 (VSSOSC), U703.J5 (VSS), U703.J6 (VSS), U703.J8 (VSS), U703.J9 (VSS), U703.J10 (VSS), U703.J11 (VSS), U703.J12 (VSS), U703.K8 (VSS), U703.K9 (VSS), U703.K10 (VSS), U703.K11 (VSS), U703.K12 (VSS), U703.K14 (VSS), U703.K15 (VSS), U703.L5 (VSS), U703.L6 (VSS), U703.L8 (VSS)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; also elsewhere on the board
unnamed: R715.1, SW701.2
unnamed: C701.1, C703.1, R712.2, U701.3 (SENSE), U701.4 (SET), U701.5 (VDD), U702.4 (SET), U702.5 (VDD)
unnamed: R704.1, U701.1 (UV), U702.1 (UV)
unnamed: C705.1, R714.2, U704.7 (VDD), U704.8 (OE)
unnamed: R707.2, U704.2 (Q1)
unnamed: R708.2, U704.3 (Q2)
unnamed: R709.2, U704.4 (Q3)
unnamed: R710.2, U704.5 (Q4)
unnamed: C704.1, R713.2, Y701.1 (Tri-State), Y701.4 (Vdd)
P0_CLK_25MHz: R709.1; also elsewhere on the board
P1_CLK_25MHz: R708.1; also elsewhere on the board
TCK_HV: U703.V15 (TCK); also elsewhere on the board
TDI_HV: U703.W13 (TDI); also elsewhere on the board
TDO_HV: U703.W15 (TDO); also elsewhere on the board
TMS_HV: R705.2, U703.W14 (TMS); also elsewhere on the board
TRST_HV: R706.1, U703.V14 (TRSTn); also elsewhere on the board

Notes on the sheet:
Power Supply Monitor
F2838D MCU Supply Pins
Reset Switch
JTAG, CLK, Reset
F28388D MCU Decoupling Capacitors
For discharge
Clock Buffer
25MHz Clock
Boot Mode Pins

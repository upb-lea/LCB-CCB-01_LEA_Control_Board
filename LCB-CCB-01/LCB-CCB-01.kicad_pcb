# Repository upb-lea/LCB-CCB-01_LEA_Control_Board (continued)

## KiCad design LCB-CCB-01/LCB-CCB-01.kicad_pcb (continued)

Parts:
U703: TMS320F28388D; BGA-361_19x19_16.0x16.0mm; mouser# 595-F28388DZWTSR

Connections:
CANA_RX|GPIO36: U703.V16 (GPIO_36); also elsewhere on the board
CANA_TX|GPIO37: U703.U16 (GPIO_37); also elsewhere on the board
CANB_RX|GPIO39: U703.W17 (GPIO_39); also elsewhere on the board
CANB_TX|GPIO38: U703.T16 (GPIO_38); also elsewhere on the board
CM-I2CA_SCL|GPIO32: U703.U13 (GPIO_32); also elsewhere on the board
CM-I2CA_SDA|GPIO31: U703.U11 (GPIO_31); also elsewhere on the board
ENET_MDIO_CLK|GPIO105: U703.J3 (GPIO_105); also elsewhere on the board
ENET_MDIO_DATA|GPIO106: U703.L2 (GPIO_106); also elsewhere on the board
ENET_MII_COL|GPIO110: U703.M2 (GPIO_110); also elsewhere on the board
ENET_MII_CRS|GPIO109: U703.N2 (GPIO_109); also elsewhere on the board
ENET_MII_INTR|GPIO108: U703.L4 (GPIO_108); also elsewhere on the board
ENET_MII_RX_CLK|GPIO111: U703.M4 (GPIO_111); also elsewhere on the board
ENET_MII_RX_DV|GPIO112: U703.M3 (GPIO_112); also elsewhere on the board
ENET_MII_RX_Data0|GPIO114: U703.N3 (GPIO_114); also elsewhere on the board
ENET_MII_RX_Data1|GPIO115: U703.V12 (GPIO_115); also elsewhere on the board
ENET_MII_RX_Data2|GPIO116: U703.W10 (GPIO_116); also elsewhere on the board
ENET_MII_RX_Data3|GPIO117: U703.U12 (GPIO_117); also elsewhere on the board
ENET_MII_RX_ERR|GPIO113: U703.N4 (GPIO_113); also elsewhere on the board
ENET_MII_TX_CLK|GPIO120: U703.U15 (GPIO_120); also elsewhere on the board
ENET_MII_TX_Data0|GPIO121: U703.W16 (GPIO_121); also elsewhere on the board
ENET_MII_TX_Data1|GPIO122: U703.T8 (GPIO_122); also elsewhere on the board
ENET_MII_TX_Data2|GPIO123: U703.U8 (GPIO_123); also elsewhere on the board
ENET_MII_TX_Data3|GPIO124: U703.V8 (GPIO_124); also elsewhere on the board
ENET_MII_TX_EN|GPIO118: U703.T12 (GPIO_118); also elsewhere on the board
ENET_MII_TX_ERR|GPIO119: U703.T15 (GPIO_119); also elsewhere on the board
ENET_PPS1|GPIO48: U703.R16 (GPIO_48); also elsewhere on the board
ENET_PPSO|GPIO47: U703.E18 (GPIO_47); also elsewhere on the board
ENET_REVMII_MDIO_RST|GPIO107: U703.L3 (GPIO_107); also elsewhere on the board
ENET_RMII_CLK|GPIO73: U703.A16 (GPIO_73); also elsewhere on the board
EPWM1A|GPIO145: U703.E17 (GPIO_145); also elsewhere on the board
EPWM1B|GPIO146: U703.D18 (GPIO_146); also elsewhere on the board
EPWM2A|GPIO147: U703.D17 (GPIO_147); also elsewhere on the board
EPWM2B|GPIO148: U703.D14 (GPIO_148); also elsewhere on the board
EPWM3A|GPIO149: U703.A13 (GPIO_149); also elsewhere on the board
EPWM3B|GPIO150: U703.B13 (GPIO_150); also elsewhere on the board
EPWM4A|GPIO151: U703.C13 (GPIO_151); also elsewhere on the board
EPWM4B|GPIO152: U703.D13 (GPIO_152); also elsewhere on the board
EPWM5A|GPIO8: U703.G2 (GPIO_8); also elsewhere on the board
EPWM5B|GPIO9: U703.G3 (GPIO_9); also elsewhere on the board
EPWM6A|GPIO155: U703.C12 (GPIO_155); also elsewhere on the board
EPWM6B|GPIO156: U703.D12 (GPIO_156); also elsewhere on the board
EPWM7A|GPIO157: U703.B10 (GPIO_157); also elsewhere on the board
EPWM7B|GPIO158: U703.C10 (GPIO_158); also elsewhere on the board
EPWM8A|GPIO159: U703.D10 (GPIO_159); also elsewhere on the board
EPWM8B|GPIO160: U703.B9 (GPIO_160); also elsewhere on the board
EPWM9A|GPIO161: U703.C9 (GPIO_161); also elsewhere on the board
EPWM9B|GPIO162: U703.D9 (GPIO_162); also elsewhere on the board
EPWM10A|GPIO163: U703.A8 (GPIO_163); also elsewhere on the board
EPWM10B|GPIO164: U703.B8 (GPIO_164); also elsewhere on the board
EPWM11A|GPIO165: U703.C5 (GPIO_165); also elsewhere on the board
EPWM11B|GPIO166: U703.D5 (GPIO_166); also elsewhere on the board
EPWM12A|GPIO167: U703.C4 (GPIO_167); also elsewhere on the board
EPWM12B|GPIO168: U703.D4 (GPIO_168); also elsewhere on the board
EPWM13A|GPIO137: U703.T18 (GPIO_137); also elsewhere on the board
EPWM13B|GPIO138: U703.T19 (GPIO_138); also elsewhere on the board
EPWM14A|GPIO139: U703.N19 (GPIO_139); also elsewhere on the board
EPWM14B|GPIO140: U703.M19 (GPIO_140); also elsewhere on the board
EPWM15A|GPIO141: U703.M18 (GPIO_141); also elsewhere on the board
EPWM15B|GPIO142: U703.L19 (GPIO_142); also elsewhere on the board
EPWM16A|GPIO143: U703.F18 (GPIO_143); also elsewhere on the board
EPWM16B|GPIO144: U703.F17 (GPIO_144); also elsewhere on the board
ESC_I2C_SCL|GPIO30: U703.T11 (GPIO_30); also elsewhere on the board
ESC_I2C_SDA|GPIO29: U703.W11 (GPIO_29); also elsewhere on the board
ESC_LATCH0|GPIO125: U703.T9 (GPIO_125); also elsewhere on the board
ESC_LATCH1|GPIO126: U703.U9 (GPIO_126); also elsewhere on the board
ESC_LED_ERR|GPIO60: U703.M17 (GPIO_60); also elsewhere on the board
ESC_LED_LINK0_ACTIVE|GPIO58: U703.N17 (GPIO_58); also elsewhere on the board
ESC_LED_LINK1_ACTIVE|GPIO59: U703.M16 (GPIO_59); also elsewhere on the board
ESC_LED_RUN|GPIO61: U703.L16 (GPIO_61); also elsewhere on the board
ESC_LED_STATE_RUN|GPIO62: U703.J17 (GPIO_62); also elsewhere on the board
ESC_MDIO_CLK|GPIO46: U703.E19 (GPIO_46); also elsewhere on the board
ESC_MDIO_DATA|GPIO153: U703.A12 (GPIO_153); also elsewhere on the board
ESC_PHY0_LINKSTATUS|GPIO86: U703.C11 (GPIO_86); also elsewhere on the board
ESC_PHY1_LINKSTATUS|GPIO68: U703.C18 (GPIO_68); also elsewhere on the board
ESC_PHY_CLK|GPIO154: U703.B12 (GPIO_154); also elsewhere on the board
ESC_PHY_RESETn|GPIO76: U703.C16 (GPIO_76); also elsewhere on the board
ESC_RX0_CLK|GPIO77: U703.A15 (GPIO_77); also elsewhere on the board
ESC_RX0_DATA0|GPIO80: U703.D15 (GPIO_80); also elsewhere on the board
ESC_RX0_DATA1|GPIO81: U703.A14 (GPIO_81); also elsewhere on the board
ESC_RX0_DATA2|GPIO82: U703.B14 (GPIO_82); also elsewhere on the board
ESC_RX0_DATA3|GPIO83: U703.C14 (GPIO_83); also elsewhere on the board
ESC_RX0_DV|GPIO78: U703.B15 (GPIO_78); also elsewhere on the board
ESC_RX0_ERR|GPIO79: U703.C15 (GPIO_79); also elsewhere on the board
ESC_RX1_CLK|GPIO69: U703.B18 (GPIO_69); also elsewhere on the board
ESC_RX1_DATA0|GPIO63: U703.J16 (GPIO_63); also elsewhere on the board
ESC_RX1_DATA1|GPIO64: U703.L17 (GPIO_64); also elsewhere on the board
ESC_RX1_DATA2|GPIO65: U703.K16 (GPIO_65); also elsewhere on the board
ESC_RX1_DATA3|GPIO66: U703.K17 (GPIO_66); also elsewhere on the board
ESC_RX1_DV|GPIO136: U703.T17 (GPIO_136); also elsewhere on the board
ESC_RX1_ERR|GPIO71: U703.B17 (GPIO_71); also elsewhere on the board
ESC_SYNC0|GPIO127: U703.V9 (GPIO_127); also elsewhere on the board
ESC_SYNC1|GPIO128: U703.W9 (GPIO_128); also elsewhere on the board
ESC_TX0_CLK|GPIO85: U703.B11 (GPIO_85); also elsewhere on the board
ESC_TX0_DATA0|GPIO87: U703.D11 (GPIO_87); also elsewhere on the board
ESC_TX0_DATA1|GPIO88: U703.C6 (GPIO_88); also elsewhere on the board
ESC_TX0_DATA2|GPIO89: U703.D6 (GPIO_89); also elsewhere on the board
ESC_TX0_DATA3|GPIO90: U703.A5 (GPIO_90); also elsewhere on the board
ESC_TX0_ENA|GPIO84: U703.A11 (GPIO_84); also elsewhere on the board
ESC_TX1_CLK|GPIO130: U703.U10 (GPIO_130); also elsewhere on the board
ESC_TX1_DATA0|GPIO131: U703.V10 (GPIO_131); also elsewhere on the board
ESC_TX1_DATA1|GPIO132: U703.W18 (GPIO_132); also elsewhere on the board
ESC_TX1_DATA2|GPIO134: U703.V18 (GPIO_134); also elsewhere on the board
ESC_TX1_DATA3|GPIO72: U703.B16 (GPIO_72); also elsewhere on the board
ESC_TX1_ENA|GPIO129: U703.T10 (GPIO_129); also elsewhere on the board
GPIO10_RstFF1: U703.B2 (GPIO_10); also elsewhere on the board
GPIO11_RstFF4: U703.C1 (GPIO_11); also elsewhere on the board
GPIO14_nErr4: U703.D2 (GPIO_14); also elsewhere on the board
GPIO15_Err1: U703.D3 (GPIO_15); also elsewhere on the board
GPIO20_nErr1: U703.F2 (GPIO_20); also elsewhere on the board
GPIO21_nErr2: U703.F3 (GPIO_21); also elsewhere on the board
GPIO33: U703.T13 (GPIO_33); also elsewhere on the board
GPIO34: U703.U14 (GPIO_34); also elsewhere on the board
GPIO40: U703.V17 (GPIO_40); also elsewhere on the board
GPIO41: U703.U17 (GPIO_41); also elsewhere on the board
GPIO44: U703.K18 (GPIO_44); also elsewhere on the board
GPIO45: U703.K19 (GPIO_45); also elsewhere on the board
GPIO49: U703.R17 (GPIO_49); also elsewhere on the board
GPIO50: U703.R18 (GPIO_50); also elsewhere on the board
GPIO51: U703.R19 (GPIO_51); also elsewhere on the board
GPIO52: U703.P16 (GPIO_52); also elsewhere on the board
GPIO53: U703.P17 (GPIO_53); also elsewhere on the board
GPIO95_Err2: U703.B3 (GPIO_95); also elsewhere on the board
GPIO96_Err4: U703.C3 (GPIO_96); also elsewhere on the board
GPIO97_RstFF2: U703.A2 (GPIO_97); also elsewhere on the board
GPIO98_RstFF3: U703.F1 (GPIO_98); also elsewhere on the board
GPIO99_Err3: U703.G1 (GPIO_99); also elsewhere on the board
GPIO104_nErr3: U703.J2 (GPIO_104); also elsewhere on the board
I2CA_SCL|GPIO1: U703.D8 (GPIO_1); also elsewhere on the board
I2CA_SDA|GPIO0: U703.C8 (GPIO_0); also elsewhere on the board
LED_Green|GPIO3: U703.B7 (GPIO_3); also elsewhere on the board
LED_Green|GPIO5: U703.D7 (GPIO_5); also elsewhere on the board
LED_Red|GPIO6: U703.A6 (GPIO_6); also elsewhere on the board
LED_Red|GPIO7: U703.B6 (GPIO_7); also elsewhere on the board
LED_Yellow|GPIO2: U703.A7 (GPIO_2); also elsewhere on the board
MCAN_RX|GPIO70: U703.A17 (GPIO_70); also elsewhere on the board
MCAN_TX|GPIO4: U703.C7 (GPIO_4); also elsewhere on the board
SCIA_RX_HV: U703.V11 (GPIO_28); also elsewhere on the board
SCIA_TX_HV: U703.U18 (GPIO_135); also elsewhere on the board
SCIB_RX|GPIO23: U703.K4 (GPIO_23); also elsewhere on the board
SCIB_TX|GPIO22: U703.J4 (GPIO_22); also elsewhere on the board
SCIC_RX|GPIO13: U703.D1 (GPIO_13); also elsewhere on the board
SCIC_TX|GPIO12: U703.C2 (GPIO_12); also elsewhere on the board
SPIA_CLK|GPIO18: U703.E3 (GPIO_18); also elsewhere on the board
SPIA_MISO|GPIO17: U703.E2 (GPIO_17); also elsewhere on the board
SPIA_MOSI|GPIO16: U703.E1 (GPIO_16); also elsewhere on the board
SPIA_STEn|GPIO19: U703.E4 (GPIO_19); also elsewhere on the board
SPIB_CLK|GPIO26: U703.K1 (GPIO_26); also elsewhere on the board
SPIB_MISO|GPIO25: U703.K2 (GPIO_25); also elsewhere on the board
SPIB_MOSI|GPIO24: U703.K3 (GPIO_24); also elsewhere on the board
SPIB_STEn|GPIO27: U703.L1 (GPIO_27); also elsewhere on the board
SPIC_CLK|GPIO102: U703.H3 (GPIO_102); also elsewhere on the board
SPIC_MISO|GPIO101: U703.H2 (GPIO_101); also elsewhere on the board
SPIC_MOSI|GPIO100: U703.H1 (GPIO_100); also elsewhere on the board
SPIC_STEn|GPIO103: U703.J1 (GPIO_103); also elsewhere on the board
SPID_CLK|GPIO93: U703.B4 (GPIO_93); also elsewhere on the board
SPID_MISO|GPIO92: U703.A4 (GPIO_92); also elsewhere on the board
SPID_MOSI|GPIO91: U703.B5 (GPIO_91); also elsewhere on the board
SPID_STEn|GPIO94: U703.A3 (GPIO_94); also elsewhere on the board
SSIA_CLK|GPIO56: U703.N16 (GPIO_56); also elsewhere on the board
SSIA_FSS|GPIO57: U703.N18 (GPIO_57); also elsewhere on the board
SSIA_RX|GPIO55: U703.P19 (GPIO_55); also elsewhere on the board
SSIA_TX|GPIO54: U703.P18 (GPIO_54); also elsewhere on the board
UARTA_RX|GPIO43: U703.C19 (GPIO_43); also elsewhere on the board
UARTA_TX|GPIO42: U703.D19 (GPIO_42); also elsewhere on the board

Notes on the sheet:
F28388D MCU GPIO Configuration

Parts:
C901, C902: 100n; C_0603; mouser# 810-C1608X5R1H104K
C905, C906, C909, C910, C913, C914, C917, C918, C921, C922, C925, C926: 100p; C_0603; mouser# 810-C1608C0G1H101KAA
C907, C908, C911, C912, C915, C916, C919, C920, C923, C924, C927, C928: 1n0; C_0603; mouser# 810-C1608X7R1H102KAE
C929: 22u; C_0603; mouser# 187-CL10A226KQ8NRNE
R901, R902, R903, R904, R905, R906, R907, R908, R909, R910, R911, R912: 1k0; R_0805; mouser# 71-CRCW08051K00FKEAC
R913, R914, R915, R916, R917, R918, R919, R920, R921, R922, R923, R924: 1k0; R_0603; mouser# 71-CRCW06031K00FKEAC
R925: 0R0; R_0603; mouser# 71-CRCW06030000Z0EAC
U703: TMS320F28388D; BGA-361_19x19_16.0x16.0mm; mouser# 595-F28388DZWTSR
U901: MAX6037AAUK30+T; SOT-23-5_Microchip; mouser# 700-MAX6037AAUK30T

Connections:
+3.3V_HV: C901.2, U901.3 (~SHDN), U901.4 (IN); also elsewhere on the board
/Analog Filter - Page 9/A0_P: C915.1, R911.1, U703.U1 (ADCINA0/DACOUTA)
/Analog Filter - Page 9/A1_N: C916.1, R912.1, U703.T1 (ADCINA1/DACOUTB)
/Analog Filter - Page 9/A2_P: C905.1, R901.1, U703.U2 (ADCINA2/CMPIN1P)
/Analog Filter - Page 9/A3_N: C906.1, R902.1, U703.T2 (ADCINA3/CMPIN1N)
/Analog Filter - Page 9/A4_P: C907.1, R903.1, U703.U3 (ADCINA4/CMPIN2P)
/Analog Filter - Page 9/A5_N: C908.1, R904.1, U703.T3 (ADCINA5/CMPIN2N)
/Analog Filter - Page 9/ADC_Ref3.0V: C902.1, R925.1, U901.5 (OUT)
/Analog Filter - Page 9/B0_P: C921.1, R917.1, U703.V2 (ADCINB0/VDAC)
/Analog Filter - Page 9/B1_N: C922.1, R918.1, U703.W2 (ADCINB1/DACOUTC)
/Analog Filter - Page 9/B2_P: C913.1, R909.1, U703.V3 (ADCINB2/CMPIN3P)
/Analog Filter - Page 9/B3_N: C914.1, R910.1, U703.W3 (ADCINB3/CMPIN3N)
/Analog Filter - Page 9/B4_P: C911.1, R907.1, U703.V4 (ADCINB4)
/Analog Filter - Page 9/B5_N: C912.1, R908.1, U703.W4 (ADCINB5)
/Analog Filter - Page 9/C2_P: C909.1, R905.1, U703.R3 (ADCINC2/CMPIN6P)
/Analog Filter - Page 9/C3_N: C910.1, R906.1, U703.P3 (ADCINC3/CMPIN6N)
/Analog Filter - Page 9/C4_P: C918.1, R914.1, U703.R4 (ADCINC4/CMPIN5P)
/Analog Filter - Page 9/C5_N: C917.1, R913.1, U703.P4 (ADCINC5/CMPIN5N)
/Analog Filter - Page 9/D0_P: C926.1, R922.1, U703.T5 (ADCIND0/CMPIN7P)
/Analog Filter - Page 9/D1_N: C925.1, R921.1, U703.U5 (ADCIND1/CMPIN7N)
/Analog Filter - Page 9/D2_P: C923.1, R919.1, U703.T6 (ADCIND2/CMPIN8P)
/Analog Filter - Page 9/D3_N: C924.1, R920.1, U703.U6 (ADCIND3/CMPIN8N)
/Analog Filter - Page 9/D4_P: C928.1, R924.1, U703.T7 (ADCIND4)
/Analog Filter - Page 9/D5_N: C927.1, R923.1, U703.U7 (ADCIND5)
/Analog Filter - Page 9/IN14_P: C919.1, R915.1, U703.T4 (ADCIN14/CMPIN4P)
/Analog Filter - Page 9/IN15_N: C920.1, R916.1, U703.U4 (ADCIN15/CMPIN4N)
/Analog Filter - Page 9/VREFH: C929.1, R925.2, U703.R1 (VREFHIC), U703.V1 (VREFHIA), U703.V5 (VREFHID), U703.W5 (VREFHIB)
ADC_A0_P: R911.2; also elsewhere on the board
ADC_A1_N: R912.2; also elsewhere on the board
ADC_A2_P: R901.2; also elsewhere on the board
ADC_A3_N: R902.2; also elsewhere on the board
ADC_A4_P: R903.2; also elsewhere on the board
ADC_A5_N: R904.2; also elsewhere on the board
ADC_B0_P: R917.2; also elsewhere on the board
ADC_B1_N: R918.2; also elsewhere on the board
ADC_B2_P: R909.2; also elsewhere on the board
ADC_B3_N: R910.2; also elsewhere on the board
ADC_B4_P: R907.2; also elsewhere on the board
ADC_B5_N: R908.2; also elsewhere on the board
ADC_C2_P: R905.2; also elsewhere on the board
ADC_C3_N: R906.2; also elsewhere on the board
ADC_C4_P: R914.2; also elsewhere on the board
ADC_C5_N: R913.2; also elsewhere on the board
ADC_D0_P: R922.2; also elsewhere on the board
ADC_D1_N: R921.2; also elsewhere on the board
ADC_D2_P: R919.2; also elsewhere on the board
ADC_D3_N: R920.2; also elsewhere on the board
ADC_D4_P: R924.2; also elsewhere on the board
ADC_D5_N: R923.2; also elsewhere on the board
ADC_IN14_P: R915.2; also elsewhere on the board
ADC_IN15_N: R916.2; also elsewhere on the board
GND_HV: C901.1, C902.2, C905.2, C906.2, C907.2, C908.2, C909.2, C910.2, C911.2, C912.2, C913.2, C914.2, C915.2, C916.2, C917.2, C918.2, C919.2, C920.2, C921.2, C922.2, C923.2, C924.2, C925.2, C926.2, C927.2, C928.2, C929.2, U703.P2 (VREFLOC), U703.R2 (VREFLOA), U703.V6 (VREFLOB), U703.W6 (VREFLOD), U901.2 (GND); also elsewhere on the board

Notes on the sheet:
Analog Input Filter MCU F28388D
3V Reference Voltage
Tau_2
Tau_1
Tau_1 = 100ns = 1kOhm * 100pF
Tau_2 = 1µs = 1kOhm * 1nF

Parts:
D1001, D1002, D1003: 2mA; LED_0603_G; mouser# 604-APTD1608LCGCK
D1004: 2mA; LED_0603_Y; mouser# 604-APTD1608LSYCK
D1005, D1006: 2mA; LED_0603_R; mouser# 604-APHD1608LSURCK
R1001, R1002, R1003, R1004, R1005, R1006: 680R; R_0603; mouser# 71-CRCW0603680RFKEAC

Connections:
+3.3V_HV: D1001.A; also elsewhere on the board
GND_HV: R1001.1, R1002.1, R1003.1, R1004.1, R1005.1, R1006.1; also elsewhere on the board
LED_Green|GPIO3: D1003.A; also elsewhere on the board
LED_Green|GPIO5: D1002.A; also elsewhere on the board
LED_Red|GPIO6: D1005.A; also elsewhere on the board
LED_Red|GPIO7: D1006.A; also elsewhere on the board
LED_Yellow|GPIO2: D1004.A; also elsewhere on the board
unnamed: D1001.C, R1001.2
unnamed: D1002.C, R1002.2
unnamed: D1003.C, R1003.2
unnamed: D1004.C, R1004.2
unnamed: D1005.C, R1005.2
unnamed: D1006.C, R1006.2

Notes on the sheet:
Status LEDs
Power LED

Parts:
C601, C602: 1u0; C_0603; mouser# 810-C1608X5R1H105K
C603, C604, C605, C607, C608: 2u2; C_0603; mouser# 810-C1608X5R1V225K
L601, L603: 60R/3A5; L_0603; mouser# 810-MPZ1608S600ATAH0
R601: 0R0; R_0603; mouser# 71-CRCW06030000Z0EAC
TP601, TP602, TP603, TP604: TestPoint_Probe; TestPoint_Pad_D1.0mm
U601: MIC5504-1.2YM5-TR; SOT-23-5_Microchip; mouser# 998-MIC5504-1.2YM5TR

Connections:
+1.2V_HV: C608.2, L603.1; also elsewhere on the board
+1V2_HV: C602.2, C607.2, L603.2, TP603.1, U601.5 (VOUT)
+3.3V_HV: C604.2, C605.2, L601.1, R601.1, TP601.1; also elsewhere on the board
+3V3_Connector_HV: C603.2, L601.2; also elsewhere on the board
GND_HV: C601.1, C602.1, C603.1, C604.1, C605.1, C607.1, C608.1, TP602.1, TP604.1, U601.2 (GND); also elsewhere on the board
unnamed: C601.2, R601.2, U601.1 (VIN), U601.3 (EN)

Notes on the sheet:
LDO 1.2V for MCU Core
Ferrit Beads

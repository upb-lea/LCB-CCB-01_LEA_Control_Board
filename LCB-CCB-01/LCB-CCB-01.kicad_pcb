# Repository upb-lea/LCB-CCB-01_LEA_Control_Board (continued)

## KiCad design hardware/03_Shield_boards/LCB-CDB-001_Dock/Dock.kicad_pcb

Board: 4 copper layers, 165.6 x 122.4 mm, 135 parts (0 on the bottom side), 267 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10: 100n; C_0603
C11, C13, C14: 10u; C_0603
C12: 10n; C_0603
D1, D2, D3, D4, D5, D6: LED_SML-P11MTT86R; LED_0402
D7, D8, D9, D10: LED_SML-P11UTT86R; LED_0402
D11, D12, D13, D14: LED_SML-P11YTT86R; LED_0402
D15: BAS3010A03WE6327HTSA1; SOD-323_Infineon
J1: LCB_connector_top
J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28, J29, J30, J31, J32, J33, J34, J35, J36, J37, J38, J39, J40, J41, J42, J43, J44, J45, J46, J47, J48, J49, J50, J51, J52, J53, J54, J55, J56, J57, J58: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J59: USBC_GTC_USB4110-GF-A; USB_C_GCT_USB4110-GF-A
J60, J61, J62, J63: Conn_02x30_Row_Letter_Last; PinHeader_2x30_P2.54mm_Vertical
O1: LEA_Logo; lea_logo
O2, O3: Fiducial_medium; Fiducials_medium
R1, R2, R3, R4: 100k; R_0603
R5, R6, R7, R8: 100R; R_0603
R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23: R_0603_680R_THICK__1P__75V; R_0603
R24: 0R; R_0402
R25, R26: 5k; R_0603
RV1, RV2, RV3, RV4: 10k; Potentiometer_Bourns_PTV09A-1_Single_Vertical
S1, S2, S3, S4: SW_2MS1T1B1M2QES
SW1, SW2, SW3, SW4: SW_Push
U1, U2: ST_6CH_CMOS_SOIC14_MC74HC14ADG; SOIC-14
U3: TPS73733DCQ; SOT-223-6_TI

Connections:
+3V3: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C13.1, C14.1, D6.A, J1.1, J1.2, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, J1.9, J1.10, J11.1, J13.1, J15.1, J18.1, J23.1, J25.1, J27.1, J30.1, J35.1, J37.1, J39.1, J41.1, J43.1, J45.1, J47.1, J49.1, J51.1, J53.1, J55.1, J57.1, J60.1a, J60.1b, J60.2a, J60.2b, J60.3a, J60.3b, J60.4a, J60.4b, R1.2, R2.2, R3.2, R4.2, U1.14 (VCC), U2.14 (VCC), U3.2 (OUT)
+5V_LV: C11.1, D3.A, D15.C, U3.1 (IN), U3.5 (EN)
ADC_A0A1_N: J1.116, J61.13b
ADC_A0A1_P: J1.118, J61.14b
ADC_A2A3_N: J1.121, J61.16a
ADC_A2A3_P: J1.123, J61.17a
ADC_A4A5_N: J1.122, J61.16b
ADC_A4A5_P: J1.124, J61.17b
ADC_B0B1_N: J1.127, J61.19a
ADC_B0B1_P: J1.129, J61.20a
ADC_B2B3_N: J1.128, J61.19b
ADC_B2B3_P: J1.130, J61.20b
ADC_B4B5_N: J1.133, J61.22a
ADC_B4B5_P: J1.135, J61.23a
ADC_C2C3_N: J1.134, J61.22b
ADC_C2C3_P: J1.136, J61.23b
ADC_C4C5_N: J1.139, J61.25a
ADC_C4C5_P: J1.141, J61.26a
ADC_D0D1_N: J1.140, J61.25b
ADC_D0D1_P: J1.142, J61.26b
ADC_D2D3_N: J1.145, J61.28a
ADC_D2D3_P: J1.147, J61.29a
ADC_D4D5_N: J1.146, J61.28b
ADC_D4D5_P: J1.148, J61.29b
ADC_IN1415_N: J1.115, J61.13a
ADC_IN1415_P: J1.117, J61.14a
CANA_RX|GPIO36: J1.291, J63.27a
CANA_TX|GPIO37: J1.292, J63.27b
CANB_RX|GPIO39: J1.287, J63.26a
CANB_TX|GPIO38: J1.288, J63.26b
CM-I2CA_SCL|GPIO32: J1.294, J63.28b
CM-I2CA_SDA|GPIO31: J1.293, J63.28a
ENET_CLK_25MHz: J1.91, J61.7a
ENET_MDIO_CLK|GPIO105: J1.61, J60.24a
ENET_MDIO_DATA|GPIO106: J1.67, J60.27a
ENET_MII_COL|GPIO110: J1.69, J60.28a
ENET_MII_CRS|GPIO109: J1.73, J60.29a
ENET_MII_INTR|GPIO108: J1.63, J60.26a
ENET_MII_RX_CLK|GPIO111: J1.75, J60.30a
ENET_MII_RX_DV|GPIO112: J1.70, J60.28b
ENET_MII_RX_Data0|GPIO114: J1.76, J60.30b
ENET_MII_RX_Data1|GPIO115: J1.87, J61.5a
ENET_MII_RX_Data2|GPIO116: J1.92, J61.7b
ENET_MII_RX_Data3|GPIO117: J1.88, J61.5b
ENET_MII_RX_ERR|GPIO113: J1.79, J61.2a
ENET_MII_TX_CLK|GPIO120: J1.86, J61.4b
ENET_MII_TX_Data0|GPIO121: J1.90, J61.6b
ENET_MII_TX_Data1|GPIO122: J1.80, J61.2b
ENET_MII_TX_Data2|GPIO123: J1.85, J61.4a
ENET_MII_TX_Data3|GPIO124: J1.89, J61.6a
ENET_MII_TX_EN|GPIO118: J1.81, J61.3a
ENET_MII_TX_ERR|GPIO119: J1.82, J61.3b
ENET_PPS1|GPIO48: J1.74, J60.29b
ENET_PPSO|GPIO47: J1.64, J60.26b
ENET_REVMII_MDIO_RST|GPIO107: J1.68, J60.27b
ENET_RMII_CLK|GPIO73: J1.62, J60.25b
EPWM1A|GPIO145: J1.153, J62.1a
EPWM1B|GPIO146: J1.154, J62.1b
EPWM2A|GPIO147: J1.155, J62.2a
EPWM2B|GPIO148: J1.156, J62.2b
EPWM3A|PGIO149: J1.159, J62.3a
EPWM3B|GPIO150: J1.160, J62.3b
EPWM4A|GPIO151: J1.161, J62.4a
EPWM4B|GPIO152: J1.162, J62.4b
EPWM5A|GPIO8: J1.165, J62.5a
EPWM5B|GPIO9: J1.166, J62.5b
EPWM6A|GPIO155: J1.167, J62.7a
EPWM6B|GPIO156: J1.168, J62.7b
EPWM7A|GPIO157: J1.171, J62.8a
EPWM7B|GPIO158: J1.172, J62.8b
EPWM8A|GPIO159: J1.173, J62.9a
EPWM8B|GPIO160: J1.174, J62.9b
EPWM9A|GPIO161: J1.177, J62.10a
EPWM9B|GPIO162: J1.178, J62.10b
EPWM10A|GPIO163: J1.179, J62.11a
EPWM10B|GPIO164: J1.180, J62.11b
EPWM11A|GPIO165: J1.183, J62.13a
EPWM11B|GPIO166: J1.184, J62.13b
EPWM12A|GPIO167: J1.185, J62.14a
EPWM12B|GPIO168: J1.186, J62.14b
EPWM13A|GPIO137: J1.189, J62.15a
EPWM13B|GPIO138: J1.190, J62.15b
EPWM14A|GPIO139: J1.191, J62.16a
EPWM14B|GPIO140: J1.192, J62.16b
EPWM15A|GPIO141: J1.195, J62.17a
EPWM15B|GPIO142: J1.196, J62.17b
EPWM16A|GPIO143: J1.197, J62.19a
EPWM16B|GPIO144: J1.198, J62.19b
ESC_I2C_SCL|GPIO30: J1.256, J63.12b
ESC_I2C_SDA|GPIO29: J1.258, J63.14b
ESC_LATCH0|GPIO125: J1.257, J63.14a
ESC_LATCH1|GPIO126: J1.261, J63.15a
ESC_LED_ERR|GPIO60: J1.245, J63.9a
ESC_LED_LINK0_ACTIVE|GPIO58: J1.250, J63.10b
ESC_LED_LINK1_ACTIVE|GPIO59: J1.246, J63.9b
ESC_LED_RUN|GPIO61: J1.240, J63.6b
ESC_LED_STATE_RUN|GPIO62: J1.233, J63.4a
ESC_MDIO_CLK|GPIO46: J1.208, J62.22b
ESC_MDIO_DATA|GPIO153: J1.220, J62.27b
ESC_PHY0_LINKSTATUS|GPIO86: J1.219, J62.27a
ESC_PHY1_LINKSTATUS|GPIO68: J1.232, J63.3b
ESC_PHY_CLK|GPIO154: J1.215, J62.26a
ESC_PHY_RESETn|GPIO76: J1.234, J63.4b
ESC_RX0_CLK|GPIO77: J1.222, J62.28b
ESC_RX0_DATA0|GPIO80: J1.213, J62.25a
ESC_RX0_DATA1|GPIO81: J1.214, J62.25b
ESC_RX0_DATA2|GPIO82: J1.209, J62.23a
ESC_RX0_DATA3|GPIO83: J1.216, J62.26b
ESC_RX0_DV|GPIO78: J1.231, J63.3a
ESC_RX0_ERR|GPIO79: J1.238, J63.5b
ESC_RX1_CLK|GPIO69: J1.226, J62.29b
ESC_RX1_DATA0|GPIO63: J1.237, J63.5a
ESC_RX1_DATA1|GPIO64: J1.243, J63.8a
ESC_RX1_DATA2|GPIO65: J1.244, J63.8b
ESC_RX1_DATA3|GPIO66: J1.239, J63.6a
ESC_RX1_DV|GPIO136: J1.249, J63.10a
ESC_RX1_ERR|GPIO71: J1.225, J62.29a
ESC_SYNC0|GPIO127: J1.262, J63.15b
ESC_SYNC1|GPIO128: J1.263, J63.16a
ESC_TX0_CLK|GPIO85: J1.228, J63.2b
ESC_TX0_DATA0|GPIO87: J1.221, J62.28a
ESC_TX0_DATA1|GPIO88: J1.204, J62.21b
ESC_TX0_DATA2|GPIO89: J1.203, J62.21a
ESC_TX0_DATA3|GPIO90: J1.207, J62.22a
ESC_TX0_ENA|GPIO84: J1.210, J62.23b
ESC_TX1_CLK|GPIO130: J1.267, J63.17a
ESC_TX1_DATA0|GPIO131: J1.255, J63.12a
ESC_TX1_DATA1|GPIO132: J1.251, J63.11a
ESC_TX1_DATA2|GPIO134: J1.252, J63.11b
ESC_TX1_DATA3|GPIO72: J1.227, J63.2a
ESC_TX1_ENA|GPIO129: J1.264, J63.16b
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, J1.11, J1.12, J1.13, J1.14, J1.19, J1.20, J1.25, J1.26, J1.31, J1.32, J1.37, J1.38, J1.43, J1.44, J1.53, J1.54, J1.59, J1.60, J1.65, J1.66, J1.71, J1.72, J1.77, J1.78, J1.83, J1.84, J1.93, J1.94, J1.99, J1.100, J1.103, J1.104, J1.105, J1.106, J1.113, J1.114, J1.119, J1.120, J1.125, J1.126, J1.131, J1.132, J1.137, J1.138, J1.143, J1.144, J1.149, J1.150, J1.151, J1.152, J1.157, J1.158, J1.163, J1.164, J1.169, J1.170, J1.175, J1.176, J1.181, J1.182, J1.187, J1.188, J1.193, J1.194, J1.199, J1.200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
GPIO14_nErr4: J1.55, J60.22a
GPIO15_Err1: J1.48, J60.19b
GPIO20_nErr1: J1.47, J60.19a
GPIO21_nErr2: J1.49, J60.20a
GPIO33: J1.57, J60.23a
GPIO34: J1.58, J60.23b
GPIO40: J1.282, J63.23b
GPIO41: J1.270, J63.18b
GPIO44: J1.269, J63.18a
GPIO45: J1.268, J63.17b
GPIO49: J1.285, J63.24a
GPIO50: J1.286, J63.24b
GPIO51: J1.281, J63.23a
GPIO52: J1.279, J63.22a
GPIO53: J1.280, J63.22b
GPIO95_Err2: J1.50, J60.20b
GPIO96_Err4: J1.56, J60.22b
GPIO99_Err3: J1.52, J60.21b
GPIO104_nErr3: J1.51, J60.21a
I2CA_SCL|GPIO1: J1.21, J60.8a
I2CA_SDA|GPIO0: J1.22, J60.8b
MCAN_RX|GPIO70: J1.17, J60.7a
MCAN_TX|GPIO4: J1.18, J60.7b
unnamed: C1.1, R5.2, U1.1
unnamed: C2.1, R6.2, U1.5
unnamed: C3.1, R7.2, U1.13
unnamed: C4.1, R8.2, U2.13
unnamed: C12.1, U3.4 (NR)
unnamed: D1.A, J35.2
unnamed: D1.C, R9.1
unnamed: D2.A, J37.2
unnamed: D2.C, R10.1
unnamed: D3.C, R11.1
unnamed: D4.A, J39.2
unnamed: D4.C, R13.1
unnamed: D5.A, J41.2
unnamed: D5.C, R14.1
unnamed: D6.C, R15.1
unnamed: D7.A, J43.2
unnamed: D7.C, R16.1
unnamed: D8.A, J45.2
unnamed: D8.C, R17.1
unnamed: D9.A, J47.2
unnamed: D9.C, R18.1
unnamed: D10.A, J49.2
unnamed: D10.C, R19.1
unnamed: D11.A, J51.2
unnamed: D11.C, R20.1
unnamed: D12.A, J53.2
unnamed: D12.C, R21.1
unnamed: D13.A, J55.2
unnamed: D13.C, R22.1
unnamed: D14.A, J57.2
unnamed: D14.C, R23.1
unnamed: D15.A, J59.A4B9 (VBUS), J59.B4A9 (VBUS)
unnamed: J3.1, J3.2, U1.2, U1.3
unnamed: J4.1, J4.2, U1.6, U1.9
unnamed: J5.1, J5.2, U1.11, U1.12
unnamed: J6.1, J6.2, U2.11, U2.12
unnamed: J7.1, J7.2, U1.4
unnamed: J8.1, J8.2, U1.8
unnamed: J9.1, J9.2, U1.10
unnamed: J10.1, J10.2, U2.10
unnamed: J11.2, S1.1
unnamed: J12.1, S1.3
unnamed: J13.2, S2.1
unnamed: J14.1, S2.3
unnamed: J15.2, RV1.1
unnamed: J16.1, J16.2, RV1.2
unnamed: J17.1, RV1.3
unnamed: J18.2, RV2.1
unnamed: J19.1, J19.2, RV2.2
unnamed: J20.1, RV2.3
unnamed: J21.1, J21.2, U2.6
unnamed: J22.1, J22.2, U2.2
unnamed: J23.2, S3.1
unnamed: J24.1, S3.3
unnamed: J25.2, S4.1
unnamed: J26.1, S4.3
unnamed: J27.2, RV3.1
unnamed: J28.1, J28.2, RV3.2
unnamed: J29.1, RV3.3
unnamed: J30.2, RV4.1
unnamed: J31.1, J31.2, RV4.2
unnamed: J32.1, RV4.3
unnamed: J33.1, J33.2, U2.8
unnamed: J34.1, J34.2, U2.4
unnamed: J36.1, R9.2
unnamed: J38.1, R10.2
unnamed: J40.1, R13.2
unnamed: J42.1, R14.2
unnamed: J44.1, R16.2
unnamed: J46.1, R17.2
unnamed: J48.1, R18.2
unnamed: J50.1, R19.2
unnamed: J52.1, R20.2
unnamed: J54.1, R21.2
unnamed: J56.1, R22.2
unnamed: J58.1, R23.2
unnamed: J59.A5 (CC1), R25.1
unnamed: J59.B5 (CC2), R26.1
unnamed: J59.S (Shield), R24.2
unnamed: R1.1, R5.1, SW1.2
unnamed: R2.1, R6.1, SW2.2
unnamed: R3.1, R7.1, SW3.2
unnamed: R4.1, R8.1, SW4.2
unnamed: R11.2, R12.1
unnamed: S1.2, U2.5
unnamed: S2.2, U2.1
unnamed: S3.2, U2.9
unnamed: S4.2, U2.3
P0_CLK_25MHz: J1.298, J63.29b
P1_CLK_25MHz: J1.297, J63.29a
SCIB_RX|GPIO23: J1.46, J60.17b
SCIB_TX|GPIO22: J1.45, J60.17a
SCIC_RX|GPIO13: J1.24, J60.9b
SCIC_TX|GPIO12: J1.23, J60.9a
SPIA_CLK|GPIO18: J1.30, J60.11b
SPIA_MISO|GPIO17: J1.28, J60.10b
SPIA_MOSI|GPIO16: J1.27, J60.10a
SPIA_STEn|GPIO19: J1.29, J60.11a
SPIB_CLK|GPIO26: J1.42, J60.16b
SPIB_MISO|GPIO25: J1.40, J60.15b
SPIB_MOSI|GPIO24: J1.39, J60.15a
SPIB_STEn|GPIO27: J1.41, J60.16a
SPIC_CLK|GPIO102: J1.36, J60.14b
SPIC_MISO|GPIO101: J1.34, J60.13b
SPIC_MOSI|GPIO100: J1.33, J60.13a
SPIC_STEn|GPIO103: J1.35, J60.14a
SSIA_CLK|GPIO56: J1.274, J63.20b
SSIA_FSS|GPIO57: J1.273, J63.20a
SSIA_RX|GPIO55: J1.275, J63.21a
SSIA_TX|GPIO54: J1.276, J63.21b
UARTA_RX|GPIO43: J1.202, J62.20b
UARTA_TX|GPIO42: J1.201, J62.20a

## Commit log

2022-03-15 Upload project structure and control board LCB-CCB-01
2022-03-15 Environment variable
2022-03-15 Add schematic from Hardware Monitor Extended
2022-03-16 update 3d-model path readme for kicad6-users
2022-03-17 Add LCB-CHW-001 and LCB-CHW-002
2022-03-17 remove backup files and set gitignore
2022-03-17 remove backup from project LCB-CHW-002
2022-03-17 modify LCB-CCB-01 AGND, QR-Code
2022-03-17 Add Ref to some components, D. U. changes
2022-03-17 Silkscreen back D. U. changes
2022-03-17 finish RC change ref
2022-03-17 Update Schematic and Datasheet
2022-03-18 USB 90 Ohm correction
2022-03-18 Add Youtube video how to flash the xds100 firmware
2022-03-18 add folders to project
2022-03-29 Schematic: analog filter values change, remove designator IC. PCB: replace LXXX footprint to 0805, add fiducials top and bottom. Update documentation
2022-03-29 remove designator IC and update documentation
2022-04-27 add soic16 model
2022-04-27 update footprint
2022-04-28 change error comparator to soic-16 footprint
2022-05-17 update MAX978EEE+ to MAX978ESE+ schematic symbol
2022-07-29 add BOM
2022-07-30 change SOIC-16 3D model color
2022-07-30 add symbols, footprints and 3D models for Dock-PCB
2022-08-01 update links in bom
2022-08-08 update ferrit bead in bom
2022-08-09 add knob
2022-08-09 change label position
2022-08-09 add top footprint for connectors
2022-08-09 add dock: schematic, and basic pcb placement. no routing
2022-08-10 fix short in schematic
2022-08-11 update footprint outer lines due to DRC warnings
2022-08-11 Route Dock PCB
2022-08-11 Add gpio numbers
2022-08-12 Update Power-Symbols in Dock, Perform DRC
2022-08-15 add LEA Symbol and Footprint
2022-08-15 add changelog and improvements
2022-08-15 fix flipflop footprint: missing GND area for solder paste
2022-08-15 Dock: 3V3 and GND solder mask reference markers, more space to edge of Pcb, reduced inner layers
2022-08-16 update labels
2022-08-24 update REF-Pin resistor Debugger to 12k
2022-08-25 add missing label description connector left/right to pcb
2022-08-30 add improvements for dock
2022-09-13 change led labels and colors in future versions
2022-09-26 update docu, add further improvements
2022-09-29 initial version for component type-labels
2022-09-30 add rubber bumper pads to HWOM BOM
2022-10-06 add photo of lcb incl. pcbs
2022-11-16 update symbols and footprints
2022-11-16 update fields 'Mouser No.' -> 'mouser#' and 'Manufacturer No.' -> 'manf#'
2022-11-18 update kicadlibrary and lcb with new mouser number components
2022-11-18 add python scripts to generate bom
2022-11-18 add 0603 and 0805 vishay resistor series
2022-11-20 add 0402 resistors
2022-11-20 add capacitors 0402, 0603, 0805
2022-11-20 update hw-mon to new material-numbers
2022-11-20 update dock symols to new symbols library
2022-11-21 update 0402-capacitors in library, update some mouser#
2022-11-21 update control board components with new library data
2022-11-23 update footprint size to library symbols (R,C), add LDOs
2022-11-23 update symbols
2022-12-02 fix missing B. Mask for SMD-Shunt
2022-12-08 update smd-shunt symbol with internal 50-ohm resistor
2022-12-21 add example software
2022-12-21 add manufacturing instructions according pcb thickness and milling holes for board-to-board-connectors
2022-12-21 add 3d-model figure
2022-12-21 typo
2022-12-22 add silkscreen labels for DPT-Power connector
2022-12-22 update schematics for accessories: usb-cable, hw-mon-cable, rubber-feet, jumper and jumper cable set. Fix wrong footprint of 0402 ferrite bead to 0603
2022-12-22 fix missing connection at ferrite bead
2023-01-03 add hint for limited input for error comparators. Add to-do on improvement list.
2023-01-03 add basic description text
2023-01-09 Error comparator input singal filtering does not work as expected due to series filtering instead of parallel filtering. Add note and workaround for series filtering of input signal
2023-01-12 add comparators
2023-01-12 fix designator for automatic generated capacitors
2023-01-12 add adapter board footprint for SOIC and add wson-package to footprint library
2023-01-17 add missing adapter cables BNC/SMB to HW-MON
2023-01-18 add second rubber feet set to dock board
2023-01-18 update rubber feet symbol
2023-01-18 update fiducials to small/medium/large
2023-02-01 add adapter board LCB-ADA-01
2023-02-07 fix ferrite beads on control board (again...)
2023-02-15 add hint to apply template for xds100 programming to avoid programming problems
2023-02-15 update flashing xds100-section
2023-02-21 add hint where to find the LEA-libraries for footprint and symbols
2023-03-01 add universal zener diode
2023-03-21 update schematic pdf files
2023-03-21 update file structure, rm unecessary files
2023-03-23 update dock improvements
2023-03-24 rm .project, .cproject and .ccsproject from .gitignore
2023-03-24 add tutorial how to import a ccs-project
2023-03-29 Update README.md
    BGA solder process
2023-03-29 add hint to have equal code indentations
2023-04-09 mv HW-MON + Dock to separate repositories
2023-04-09 update file structure
2023-04-09 update drawings
2023-04-09 rename pcb
2023-04-09 mv folder
2023-04-09 mv kicad library to separate repository
2023-04-09 new library filepath
2023-04-09 update documentation
2023-04-11 signal variable renaming, update some footprints
2023-04-11 add hint for kicad-version
2023-04-12 mv software to LCB-Software repository
2023-04-26 update variable names for more readable
2023-05-05 update all PCB figure
2023-07-05 mv 3D-model instructions to LEA-Kicad-Library repo
2023-07-05 fix typo
2023-08-07 fix typo PGIO149 -> GPIO149
2023-08-28 Update README.md
    minor typo corrections (in particular no hyphens in LEA Control Board)
2023-12-20 add pin board and BOM tutorial
2024-03-20 add test-pcb to documentation
2024-05-14 add bus board
2024-05-23 kicad 8 requirement
2024-12-11 update to new kicad version
2024-12-12 fix schematic warnings
2024-12-12 footprint update, update printed version labeling
2024-12-18 add design decision hints
2024-12-19 issues fix
2024-12-20 OR addon plan
2024-12-22 0603 updates
2025-01-06 Added M3 hole, Reset switch and removed boot switch
2025-01-08 update: 0402 to 0603
2025-01-09 update: 0402->0603, Error detection part
2025-01-10 update changelog
2025-01-10 Components updates according to BOM
2025-01-17 Error det. circuit update - new packages/comps and OR gate
2025-01-20 error det. OR gates - packages update
2025-01-21 Analog RC filters
2025-01-27 updates:err det cir, debugger
2025-01-29 updated error detection sch. and layout
2025-02-03 debugger updates
2025-02-04 Fully updated debugger
2025-02-09 Error detection-Diode update
2025-02-10 debugger connections update
2025-02-19 few LED rel. changes and error det. resistance change: 33k->2.9V : 4.7k->2.6V
2025-02-19 fiducials, small routing changes
2025-02-20 error det. AND gate update
2025-02-20 silkscreen labels
2025-02-21 update metadata and docs
2025-03-31 update layer stackup
2025-04-11 mv usb c connector for better soldering on rework station and handling on placement machine
2025-05-27 mv some components close to the rework station holder, bump to 1.2.0

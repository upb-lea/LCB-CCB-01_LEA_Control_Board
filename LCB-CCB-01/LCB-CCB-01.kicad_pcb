# Repository upb-lea/LCB-CCB-01_LEA_Control_Board (continued)

## KiCad design LCB-CCB-01/LCB-CCB-01.kicad_pcb (continued)

Schematic: Connector_Top.kicad_sch, LCB-CCB-01: Control Board - Debugger XDS100 / JTAG

Parts:
J401: Molex_532617006; 6-PinHeader_Molex_532617006; mouser# 538-53261-7006
J402, J403: ERF5-075-05.0-L-DV-TR; ERF5-075-05.0-L-DV; mouser# 200-ERF507505.0LDVTR

Connections:
+3.3V_HV: J401.6; also elsewhere on the board
+3V3_Connector_HV: J402.1, J402.2, J402.3, J402.4, J402.5, J402.6, J402.7, J402.8, J402.9, J402.10; also elsewhere on the board
ADC_A0_P: J402.118; also elsewhere on the board
ADC_A1_N: J402.116; also elsewhere on the board
ADC_A2_P: J402.123; also elsewhere on the board
ADC_A3_N: J402.121; also elsewhere on the board
ADC_A4_P: J402.124; also elsewhere on the board
ADC_A5_N: J402.122; also elsewhere on the board
ADC_B0_P: J402.129; also elsewhere on the board
ADC_B1_N: J402.127; also elsewhere on the board
ADC_B2_P: J402.130; also elsewhere on the board
ADC_B3_N: J402.128; also elsewhere on the board
ADC_B4_P: J402.135; also elsewhere on the board
ADC_B5_N: J402.133; also elsewhere on the board
ADC_C2_P: J402.136; also elsewhere on the board
ADC_C3_N: J402.134; also elsewhere on the board
ADC_C4_P: J402.141; also elsewhere on the board
ADC_C5_N: J402.139; also elsewhere on the board
ADC_D0_P: J402.142; also elsewhere on the board
ADC_D1_N: J402.140; also elsewhere on the board
ADC_D2_P: J402.147; also elsewhere on the board
ADC_D3_N: J402.145; also elsewhere on the board
ADC_D4_P: J402.148; also elsewhere on the board
ADC_D5_N: J402.146; also elsewhere on the board
ADC_IN14_P: J402.117; also elsewhere on the board
ADC_IN15_N: J402.115; also elsewhere on the board
CANA_RX|GPIO36: J403.141; also elsewhere on the board
CANA_TX|GPIO37: J403.142; also elsewhere on the board
CANB_RX|GPIO39: J403.137; also elsewhere on the board
CANB_TX|GPIO38: J403.138; also elsewhere on the board
CM-I2CA_SCL|GPIO32: J403.144; also elsewhere on the board
CM-I2CA_SDA|GPIO31: J403.143; also elsewhere on the board
ENET_CLK_25MHz: J402.91; also elsewhere on the board
ENET_MDIO_CLK|GPIO105: J402.61; also elsewhere on the board
ENET_MDIO_DATA|GPIO106: J402.67; also elsewhere on the board
ENET_MII_COL|GPIO110: J402.69; also elsewhere on the board
ENET_MII_CRS|GPIO109: J402.73; also elsewhere on the board
ENET_MII_INTR|GPIO108: J402.63; also elsewhere on the board
ENET_MII_RX_CLK|GPIO111: J402.75; also elsewhere on the board
ENET_MII_RX_DV|GPIO112: J402.70; also elsewhere on the board
ENET_MII_RX_Data0|GPIO114: J402.76; also elsewhere on the board
ENET_MII_RX_Data1|GPIO115: J402.87; also elsewhere on the board
ENET_MII_RX_Data2|GPIO116: J402.92; also elsewhere on the board
ENET_MII_RX_Data3|GPIO117: J402.88; also elsewhere on the board
ENET_MII_RX_ERR|GPIO113: J402.79; also elsewhere on the board
ENET_MII_TX_CLK|GPIO120: J402.86; also elsewhere on the board
ENET_MII_TX_Data0|GPIO121: J402.90; also elsewhere on the board
ENET_MII_TX_Data1|GPIO122: J402.80; also elsewhere on the board
ENET_MII_TX_Data2|GPIO123: J402.85; also elsewhere on the board
ENET_MII_TX_Data3|GPIO124: J402.89; also elsewhere on the board
ENET_MII_TX_EN|GPIO118: J402.81; also elsewhere on the board
ENET_MII_TX_ERR|GPIO119: J402.82; also elsewhere on the board
ENET_PPS1|GPIO48: J402.74; also elsewhere on the board
ENET_PPSO|GPIO47: J402.64; also elsewhere on the board
ENET_REVMII_MDIO_RST|GPIO107: J402.68; also elsewhere on the board
ENET_RMII_CLK|GPIO73: J402.62; also elsewhere on the board
EPWM1A|GPIO145: J403.3; also elsewhere on the board
EPWM1B|GPIO146: J403.4; also elsewhere on the board
EPWM2A|GPIO147: J403.5; also elsewhere on the board
EPWM2B|GPIO148: J403.6; also elsewhere on the board
EPWM3A|GPIO149: J403.9; also elsewhere on the board
EPWM3B|GPIO150: J403.10; also elsewhere on the board
EPWM4A|GPIO151: J403.11; also elsewhere on the board
EPWM4B|GPIO152: J403.12; also elsewhere on the board
EPWM5A|GPIO8: J403.15; also elsewhere on the board
EPWM5B|GPIO9: J403.16; also elsewhere on the board
EPWM6A|GPIO155: J403.17; also elsewhere on the board
EPWM6B|GPIO156: J403.18; also elsewhere on the board
EPWM7A|GPIO157: J403.21; also elsewhere on the board
EPWM7B|GPIO158: J403.22; also elsewhere on the board
EPWM8A|GPIO159: J403.23; also elsewhere on the board
EPWM8B|GPIO160: J403.24; also elsewhere on the board
EPWM9A|GPIO161: J403.27; also elsewhere on the board
EPWM9B|GPIO162: J403.28; also elsewhere on the board
EPWM10A|GPIO163: J403.29; also elsewhere on the board
EPWM10B|GPIO164: J403.30; also elsewhere on the board
EPWM11A|GPIO165: J403.33; also elsewhere on the board
EPWM11B|GPIO166: J403.34; also elsewhere on the board
EPWM12A|GPIO167: J403.35; also elsewhere on the board
EPWM12B|GPIO168: J403.36; also elsewhere on the board
EPWM13A|GPIO137: J403.39; also elsewhere on the board
EPWM13B|GPIO138: J403.40; also elsewhere on the board
EPWM14A|GPIO139: J403.41; also elsewhere on the board
EPWM14B|GPIO140: J403.42; also elsewhere on the board
EPWM15A|GPIO141: J403.45; also elsewhere on the board
EPWM15B|GPIO142: J403.46; also elsewhere on the board
EPWM16A|GPIO143: J403.47; also elsewhere on the board
EPWM16B|GPIO144: J403.48; also elsewhere on the board
ESC_I2C_SCL|GPIO30: J403.106; also elsewhere on the board
ESC_I2C_SDA|GPIO29: J403.108; also elsewhere on the board
ESC_LATCH0|GPIO125: J403.107; also elsewhere on the board
ESC_LATCH1|GPIO126: J403.111; also elsewhere on the board
ESC_LED_ERR|GPIO60: J403.95; also elsewhere on the board
ESC_LED_LINK0_ACTIVE|GPIO58: J403.100; also elsewhere on the board
ESC_LED_LINK1_ACTIVE|GPIO59: J403.96; also elsewhere on the board
ESC_LED_RUN|GPIO61: J403.90; also elsewhere on the board
ESC_LED_STATE_RUN|GPIO62: J403.83; also elsewhere on the board
ESC_MDIO_CLK|GPIO46: J403.58; also elsewhere on the board
ESC_MDIO_DATA|GPIO153: J403.70; also elsewhere on the board
ESC_PHY0_LINKSTATUS|GPIO86: J403.69; also elsewhere on the board
ESC_PHY1_LINKSTATUS|GPIO68: J403.82; also elsewhere on the board
ESC_PHY_CLK|GPIO154: J403.65; also elsewhere on the board
ESC_PHY_RESETn|GPIO76: J403.84; also elsewhere on the board
ESC_RX0_CLK|GPIO77: J403.72; also elsewhere on the board
ESC_RX0_DATA0|GPIO80: J403.63; also elsewhere on the board
ESC_RX0_DATA1|GPIO81: J403.64; also elsewhere on the board
ESC_RX0_DATA2|GPIO82: J403.59; also elsewhere on the board
ESC_RX0_DATA3|GPIO83: J403.66; also elsewhere on the board
ESC_RX0_DV|GPIO78: J403.81; also elsewhere on the board
ESC_RX0_ERR|GPIO79: J403.88; also elsewhere on the board
ESC_RX1_CLK|GPIO69: J403.76; also elsewhere on the board
ESC_RX1_DATA0|GPIO63: J403.87; also elsewhere on the board
ESC_RX1_DATA1|GPIO64: J403.93; also elsewhere on the board
ESC_RX1_DATA2|GPIO65: J403.94; also elsewhere on the board
ESC_RX1_DATA3|GPIO66: J403.89; also elsewhere on the board
ESC_RX1_DV|GPIO136: J403.99; also elsewhere on the board
ESC_RX1_ERR|GPIO71: J403.75; also elsewhere on the board
ESC_SYNC0|GPIO127: J403.112; also elsewhere on the board
ESC_SYNC1|GPIO128: J403.113; also elsewhere on the board
ESC_TX0_CLK|GPIO85: J403.78; also elsewhere on the board
ESC_TX0_DATA0|GPIO87: J403.71; also elsewhere on the board
ESC_TX0_DATA1|GPIO88: J403.54; also elsewhere on the board
ESC_TX0_DATA2|GPIO89: J403.53; also elsewhere on the board
ESC_TX0_DATA3|GPIO90: J403.57; also elsewhere on the board
ESC_TX0_ENA|GPIO84: J403.60; also elsewhere on the board
ESC_TX1_CLK|GPIO130: J403.117; also elsewhere on the board
ESC_TX1_DATA0|GPIO131: J403.105; also elsewhere on the board
ESC_TX1_DATA1|GPIO132: J403.101; also elsewhere on the board
ESC_TX1_DATA2|GPIO134: J403.102; also elsewhere on the board
ESC_TX1_DATA3|GPIO72: J403.77; also elsewhere on the board
ESC_TX1_ENA|GPIO129: J403.114; also elsewhere on the board
FreePin1: J402.15; also elsewhere on the board
FreePin3: J402.95; also elsewhere on the board
FreePin4: J402.96; also elsewhere on the board
FreePin5: J402.97; also elsewhere on the board
FreePin6: J402.98; also elsewhere on the board
FreePin7: J402.101; also elsewhere on the board
FreePin8: J402.102; also elsewhere on the board
GND_HV: J401.1, J402.11, J402.12, J402.13, J402.14, J402.19, J402.20, J402.25, J402.26, J402.31, J402.32, J402.37, J402.38, J402.43, J402.44, J402.53, J402.54, J402.59, J402.60, J402.65, J402.66, J402.71, J402.72, J402.77, J402.78, J402.83, J402.84, J402.93, J402.94, J402.99, J402.100, J402.103, J402.104, J402.105, J402.106, J402.113, J402.114, J402.119, J402.120, J402.125, J402.126, J402.131, J402.132, J402.137, J402.138, J402.143, J402.144, J402.149, J402.150, J403.1, J403.2, J403.7, J403.8, J403.13, J403.14, J403.19, J403.20, J403.25, J403.26, J403.31, J403.32, J403.37, J403.38, J403.43, J403.44, J403.49, J403.50, J403.55, J403.56, J403.61, J403.62, J403.67, J403.68, J403.73, J403.74, J403.79, J403.80, J403.85, J403.86, J403.91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; also elsewhere on the board
GPIO14_nErr4: J402.55; also elsewhere on the board
GPIO15_Err1: J402.48; also elsewhere on the board
GPIO20_nErr1: J402.47; also elsewhere on the board
GPIO21_nErr2: J402.49; also elsewhere on the board
GPIO33: J402.57; also elsewhere on the board
GPIO34: J402.58; also elsewhere on the board
GPIO40: J403.132; also elsewhere on the board
GPIO41: J403.120; also elsewhere on the board
GPIO44: J403.119; also elsewhere on the board
GPIO45: J403.118; also elsewhere on the board
GPIO49: J403.135; also elsewhere on the board
GPIO50: J403.136; also elsewhere on the board
GPIO51: J403.131; also elsewhere on the board
GPIO52: J403.129; also elsewhere on the board
GPIO53: J403.130; also elsewhere on the board
GPIO95_Err2: J402.50; also elsewhere on the board
GPIO96_Err4: J402.56; also elsewhere on the board
GPIO99_Err3: J402.52; also elsewhere on the board
GPIO104_nErr3: J402.51; also elsewhere on the board
I2CA_SCL|GPIO1: J402.21; also elsewhere on the board
I2CA_SDA|GPIO0: J402.22; also elsewhere on the board
MCAN_RX|GPIO70: J402.17; also elsewhere on the board
MCAN_TX|GPIO4: J402.18; also elsewhere on the board
P0_CLK_25MHz: J403.148; also elsewhere on the board
P1_CLK_25MHz: J403.147; also elsewhere on the board
SCIB_RX|GPIO23: J402.46; also elsewhere on the board
SCIB_TX|GPIO22: J402.45; also elsewhere on the board
SCIC_RX|GPIO13: J402.24; also elsewhere on the board
SCIC_TX|GPIO12: J402.23; also elsewhere on the board
SPIA_CLK|GPIO18: J402.30; also elsewhere on the board
SPIA_MISO|GPIO17: J402.28; also elsewhere on the board
SPIA_MOSI|GPIO16: J402.27; also elsewhere on the board
SPIA_STEn|GPIO19: J402.29; also elsewhere on the board
SPIB_CLK|GPIO26: J402.42; also elsewhere on the board
SPIB_MISO|GPIO25: J402.40; also elsewhere on the board
SPIB_MOSI|GPIO24: J402.39; also elsewhere on the board
SPIB_STEn|GPIO27: J402.41; also elsewhere on the board
SPIC_CLK|GPIO102: J402.36; also elsewhere on the board
SPIC_MISO|GPIO101: J402.34; also elsewhere on the board
SPIC_MOSI|GPIO100: J402.33; also elsewhere on the board
SPIC_STEn|GPIO103: J402.35; also elsewhere on the board
SPID_CLK|GPIO93: J401.5; also elsewhere on the board
SPID_MISO|GPIO92: J401.3; also elsewhere on the board
SPID_MOSI|GPIO91: J401.4; also elsewhere on the board
SPID_STEn|GPIO94: J401.2; also elsewhere on the board
SSIA_CLK|GPIO56: J403.124; also elsewhere on the board
SSIA_FSS|GPIO57: J403.123; also elsewhere on the board
SSIA_RX|GPIO55: J403.125; also elsewhere on the board
SSIA_TX|GPIO54: J403.126; also elsewhere on the board
UARTA_RX|GPIO43: J403.52; also elsewhere on the board
UARTA_TX|GPIO42: J403.51; also elsewhere on the board
nErr_AND_output: J402.16; also elsewhere on the board

Notes on the sheet:
Top J402 Connector
Supply and SPI for extension board
Top J403 Connector
Supply for shield boards

Schematic: ErrorcComparator.kicad_sch, LCB-CCB-01: Control Board - Debugger XDS100 / JTAG

Parts:
C801, C804, C807, C810: 100p; C_0603; mouser# 810-C1608C0G1H101KAA
C802, C805, C808, C811: 10n; C_0603; mouser# 810-CGA3E2X7R1H103K; not fitted
C813, C814, C815, C816, C817: 100n; C_0603; mouser# 810-C1608X5R1H104K
D801, D802, D803, D804: 150mA; SOD-323_Panjit; mouser# 241-BAS316_R1_00001
R801, R802, R803, R804, R809, R810, R811, R812: 1k0; R_0603; mouser# 71-CRCW06031K00FKEAC
R805, R806, R813, R814: 4k7; R_0603; mouser# 71-CRCW06034K70FKEBC
R807, R808, R815, R816: 10k; R_0603; mouser# 71-CRCW060310K0FKEAC
R820, R821, R822, R823: 0R0; R_0603; mouser# 71-CRCW06030000Z0EAC
U801, U802: 74HC74PW; TSSOP-14-Nexperia; mouser# 771-74HC74PW-T
U803, U804: TLV3202AIDGKR; VSSOP-8-TI; mouser# 595-TLV3202AIDGKR
U805: 74ALVC08PW; TSSOP-14-Nexperia; mouser# 771-ALVC08PW118

Connections:
+3.3V_HV: R801.2, R802.2, R809.2, R810.2, R820.1, R821.1, R822.2, R823.1; also elsewhere on the board
/Error Detection - Page 8/1Y: U805.3 (1Y), U805.10 (3B)
/Error Detection - Page 8/2Y: U805.6 (2Y), U805.9 (3A)
/Error Detection - Page 8/FF1_Data: R805.2, U801.4 (SD), U803.1
/Error Detection - Page 8/FF2_Data: R813.2, U801.10 (SD), U803.7
/Error Detection - Page 8/FF3_Data: R806.2, U802.4 (SD), U804.1
/Error Detection - Page 8/FF4_Data: R814.2, U802.10 (SD), U804.7
/Error Detection - Page 8/OPA1IN+: C802.1, D801.A, R801.1, R807.2, U803.3 (+)
/Error Detection - Page 8/OPA1IN-: C801.1, R803.2, U803.2 (-)
/Error Detection - Page 8/OPA2IN+: C808.1, D803.A, R809.1, R815.2, U803.5 (+)
/Error Detection - Page 8/OPA2_IN-: C807.1, R811.2, U803.6 (-)
/Error Detection - Page 8/OPA3IN+: C805.1, D802.A, R802.1, R808.2, U804.3 (+)
/Error Detection - Page 8/OPA3IN-: C804.1, R804.2, U804.2 (-)
/Error Detection - Page 8/OPA4IN+: C811.1, D804.A, R810.1, R816.2, U804.5 (+)
/Error Detection - Page 8/OPA4IN-: C810.1, R812.2, U804.6 (-)
ADC_A2_P: R803.1; also elsewhere on the board
ADC_B2_P: R804.1; also elsewhere on the board
ADC_C4_P: R811.1; also elsewhere on the board
ADC_D0_P: R812.1; also elsewhere on the board
GND_HV: C801.2, C802.2, C804.2, C805.2, C807.2, C808.2, C810.2, C811.2, C813.2, C814.2, C815.2, C816.2, C817.2, R807.1, R808.1, R815.1, R816.1, U801.2 (D), U801.3 (CP), U801.7 (GND), U801.11 (CP), U801.12 (D), U802.2 (D), U802.3 (CP), U802.7 (GND), U802.11 (CP), U802.12 (D), U803.4 (GND), U804.4 (GND), U805.7 (GND), U805.12 (4A), U805.13 (4B); also elsewhere on the board
GPIO10_RstFF1: U801.1 (RD); also elsewhere on the board
GPIO11_RstFF4: U802.13 (RD); also elsewhere on the board
GPIO14_nErr4: U802.8 (~Q), U805.4 (2A); also elsewhere on the board
GPIO15_Err1: U801.5 (Q); also elsewhere on the board
GPIO20_nErr1: U801.6 (~Q), U805.1 (1A); also elsewhere on the board
GPIO21_nErr2: U801.8 (~Q), U805.2 (1B); also elsewhere on the board
GPIO95_Err2: U801.9 (Q); also elsewhere on the board
GPIO96_Err4: U802.9 (Q); also elsewhere on the board
GPIO97_RstFF2: U801.13 (RD); also elsewhere on the board
GPIO98_RstFF3: U802.1 (RD); also elsewhere on the board
GPIO99_Err3: U802.5 (Q); also elsewhere on the board
GPIO104_nErr3: U802.6 (~Q), U805.5 (2B); also elsewhere on the board
unnamed: D801.C, R805.1
unnamed: D802.C, R806.1
unnamed: D803.C, R813.1
unnamed: D804.C, R814.1
unnamed: C813.1, C815.1, R820.2, U801.14 (VCC), U802.14 (VCC)
unnamed: C814.1, R821.2, U803.8 (VCC)
unnamed: C816.1, R823.2, U804.8 (VCC)
unnamed: C817.1, R822.1, U805.14 (VCC)
nErr_AND_output: U805.8 (3Y); also elsewhere on the board

Notes on the sheet:
Error1 - A2
Error3 - B2
Power Supply
Error AND Gate
Error2 - C4
Error4 - D0

Schematic: Connector_Bottom.kicad_sch, LCB-CCB-01: Control Board - Debugger XDS100 / JTAG

Parts:
J501, J502: ERM5-075-05.0-L-DV-K-TR; ERM5-075-05.0-L-DV; mouser# 200-ERM5075050LDVKTR

Connections:
+3V3_Connector_HV: J501.1, J501.2, J501.3, J501.4, J501.5, J501.6, J501.7, J501.8, J501.9, J501.10; also elsewhere on the board
ADC_A0_P: J501.118; also elsewhere on the board
ADC_A1_N: J501.116; also elsewhere on the board
ADC_A2_P: J501.123; also elsewhere on the board
ADC_A3_N: J501.121; also elsewhere on the board
ADC_A4_P: J501.124; also elsewhere on the board
ADC_A5_N: J501.122; also elsewhere on the board
ADC_B0_P: J501.129; also elsewhere on the board
ADC_B1_N: J501.127; also elsewhere on the board
ADC_B2_P: J501.130; also elsewhere on the board
ADC_B3_N: J501.128; also elsewhere on the board
ADC_B4_P: J501.135; also elsewhere on the board
ADC_B5_N: J501.133; also elsewhere on the board
ADC_C2_P: J501.136; also elsewhere on the board
ADC_C3_N: J501.134; also elsewhere on the board
ADC_C4_P: J501.141; also elsewhere on the board
ADC_C5_N: J501.139; also elsewhere on the board
ADC_D0_P: J501.142; also elsewhere on the board
ADC_D1_N: J501.140; also elsewhere on the board
ADC_D2_P: J501.147; also elsewhere on the board
ADC_D3_N: J501.145; also elsewhere on the board
ADC_D4_P: J501.148; also elsewhere on the board
ADC_D5_N: J501.146; also elsewhere on the board
ADC_IN14_P: J501.117; also elsewhere on the board
ADC_IN15_N: J501.115; also elsewhere on the board
CANA_RX|GPIO36: J502.141; also elsewhere on the board
CANA_TX|GPIO37: J502.142; also elsewhere on the board
CANB_RX|GPIO39: J502.137; also elsewhere on the board
CANB_TX|GPIO38: J502.138; also elsewhere on the board
CM-I2CA_SCL|GPIO32: J502.144; also elsewhere on the board
CM-I2CA_SDA|GPIO31: J502.143; also elsewhere on the board
ENET_CLK_25MHz: J501.91; also elsewhere on the board
ENET_MDIO_CLK|GPIO105: J501.61; also elsewhere on the board
ENET_MDIO_DATA|GPIO106: J501.67; also elsewhere on the board
ENET_MII_COL|GPIO110: J501.69; also elsewhere on the board
ENET_MII_CRS|GPIO109: J501.73; also elsewhere on the board
ENET_MII_INTR|GPIO108: J501.63; also elsewhere on the board
ENET_MII_RX_CLK|GPIO111: J501.75; also elsewhere on the board
ENET_MII_RX_DV|GPIO112: J501.70; also elsewhere on the board
ENET_MII_RX_Data0|GPIO114: J501.76; also elsewhere on the board
ENET_MII_RX_Data1|GPIO115: J501.87; also elsewhere on the board
ENET_MII_RX_Data2|GPIO116: J501.92; also elsewhere on the board
ENET_MII_RX_Data3|GPIO117: J501.88; also elsewhere on the board
ENET_MII_RX_ERR|GPIO113: J501.79; also elsewhere on the board
ENET_MII_TX_CLK|GPIO120: J501.86; also elsewhere on the board
ENET_MII_TX_Data0|GPIO121: J501.90; also elsewhere on the board
ENET_MII_TX_Data1|GPIO122: J501.80; also elsewhere on the board
ENET_MII_TX_Data2|GPIO123: J501.85; also elsewhere on the board
ENET_MII_TX_Data3|GPIO124: J501.89; also elsewhere on the board
ENET_MII_TX_EN|GPIO118: J501.81; also elsewhere on the board
ENET_MII_TX_ERR|GPIO119: J501.82; also elsewhere on the board
ENET_PPS1|GPIO48: J501.74; also elsewhere on the board
ENET_PPSO|GPIO47: J501.64; also elsewhere on the board
ENET_REVMII_MDIO_RST|GPIO107: J501.68; also elsewhere on the board
ENET_RMII_CLK|GPIO73: J501.62; also elsewhere on the board
EPWM1A|GPIO145: J502.3; also elsewhere on the board
EPWM1B|GPIO146: J502.4; also elsewhere on the board
EPWM2A|GPIO147: J502.5; also elsewhere on the board
EPWM2B|GPIO148: J502.6; also elsewhere on the board
EPWM3A|GPIO149: J502.9; also elsewhere on the board
EPWM3B|GPIO150: J502.10; also elsewhere on the board
EPWM4A|GPIO151: J502.11; also elsewhere on the board
EPWM4B|GPIO152: J502.12; also elsewhere on the board
EPWM5A|GPIO8: J502.15; also elsewhere on the board
EPWM5B|GPIO9: J502.16; also elsewhere on the board
EPWM6A|GPIO155: J502.17; also elsewhere on the board
EPWM6B|GPIO156: J502.18; also elsewhere on the board
EPWM7A|GPIO157: J502.21; also elsewhere on the board
EPWM7B|GPIO158: J502.22; also elsewhere on the board
EPWM8A|GPIO159: J502.23; also elsewhere on the board
EPWM8B|GPIO160: J502.24; also elsewhere on the board
EPWM9A|GPIO161: J502.27; also elsewhere on the board
EPWM9B|GPIO162: J502.28; also elsewhere on the board
EPWM10A|GPIO163: J502.29; also elsewhere on the board
EPWM10B|GPIO164: J502.30; also elsewhere on the board
EPWM11A|GPIO165: J502.33; also elsewhere on the board
EPWM11B|GPIO166: J502.34; also elsewhere on the board
EPWM12A|GPIO167: J502.35; also elsewhere on the board
EPWM12B|GPIO168: J502.36; also elsewhere on the board
EPWM13A|GPIO137: J502.39; also elsewhere on the board
EPWM13B|GPIO138: J502.40; also elsewhere on the board
EPWM14A|GPIO139: J502.41; also elsewhere on the board
EPWM14B|GPIO140: J502.42; also elsewhere on the board
EPWM15A|GPIO141: J502.45; also elsewhere on the board
EPWM15B|GPIO142: J502.46; also elsewhere on the board
EPWM16A|GPIO143: J502.47; also elsewhere on the board
EPWM16B|GPIO144: J502.48; also elsewhere on the board
ESC_I2C_SCL|GPIO30: J502.106; also elsewhere on the board
ESC_I2C_SDA|GPIO29: J502.108; also elsewhere on the board
ESC_LATCH0|GPIO125: J502.107; also elsewhere on the board
ESC_LATCH1|GPIO126: J502.111; also elsewhere on the board
ESC_LED_ERR|GPIO60: J502.95; also elsewhere on the board
ESC_LED_LINK0_ACTIVE|GPIO58: J502.100; also elsewhere on the board
ESC_LED_LINK1_ACTIVE|GPIO59: J502.96; also elsewhere on the board
ESC_LED_RUN|GPIO61: J502.90; also elsewhere on the board
ESC_LED_STATE_RUN|GPIO62: J502.83; also elsewhere on the board
ESC_MDIO_CLK|GPIO46: J502.58; also elsewhere on the board
ESC_MDIO_DATA|GPIO153: J502.70; also elsewhere on the board
ESC_PHY0_LINKSTATUS|GPIO86: J502.69; also elsewhere on the board
ESC_PHY1_LINKSTATUS|GPIO68: J502.82; also elsewhere on the board
ESC_PHY_CLK|GPIO154: J502.65; also elsewhere on the board
ESC_PHY_RESETn|GPIO76: J502.84; also elsewhere on the board
ESC_RX0_CLK|GPIO77: J502.72; also elsewhere on the board
ESC_RX0_DATA0|GPIO80: J502.63; also elsewhere on the board
ESC_RX0_DATA1|GPIO81: J502.64; also elsewhere on the board
ESC_RX0_DATA2|GPIO82: J502.59; also elsewhere on the board
ESC_RX0_DATA3|GPIO83: J502.66; also elsewhere on the board
ESC_RX0_DV|GPIO78: J502.81; also elsewhere on the board
ESC_RX0_ERR|GPIO79: J502.88; also elsewhere on the board
ESC_RX1_CLK|GPIO69: J502.76; also elsewhere on the board
ESC_RX1_DATA0|GPIO63: J502.87; also elsewhere on the board
ESC_RX1_DATA1|GPIO64: J502.93; also elsewhere on the board
ESC_RX1_DATA2|GPIO65: J502.94; also elsewhere on the board
ESC_RX1_DATA3|GPIO66: J502.89; also elsewhere on the board
ESC_RX1_DV|GPIO136: J502.99; also elsewhere on the board
ESC_RX1_ERR|GPIO71: J502.75; also elsewhere on the board
ESC_SYNC0|GPIO127: J502.112; also elsewhere on the board
ESC_SYNC1|GPIO128: J502.113; also elsewhere on the board
ESC_TX0_CLK|GPIO85: J502.78; also elsewhere on the board
ESC_TX0_DATA0|GPIO87: J502.71; also elsewhere on the board
ESC_TX0_DATA1|GPIO88: J502.54; also elsewhere on the board
ESC_TX0_DATA2|GPIO89: J502.53; also elsewhere on the board
ESC_TX0_DATA3|GPIO90: J502.57; also elsewhere on the board
ESC_TX0_ENA|GPIO84: J502.60; also elsewhere on the board
ESC_TX1_CLK|GPIO130: J502.117; also elsewhere on the board
ESC_TX1_DATA0|GPIO131: J502.105; also elsewhere on the board
ESC_TX1_DATA1|GPIO132: J502.101; also elsewhere on the board
ESC_TX1_DATA2|GPIO134: J502.102; also elsewhere on the board
ESC_TX1_DATA3|GPIO72: J502.77; also elsewhere on the board
ESC_TX1_ENA|GPIO129: J502.114; also elsewhere on the board
FreePin1: J501.15; also elsewhere on the board
FreePin3: J501.95; also elsewhere on the board
FreePin4: J501.96; also elsewhere on the board
FreePin5: J501.97; also elsewhere on the board
FreePin6: J501.98; also elsewhere on the board
FreePin7: J501.101; also elsewhere on the board
FreePin8: J501.102; also elsewhere on the board
GND_HV: J501.11, J501.12, J501.13, J501.14, J501.19, J501.20, J501.25, J501.26, J501.31, J501.32, J501.37, J501.38, J501.43, J501.44, J501.53, J501.54, J501.59, J501.60, J501.65, J501.66, J501.71, J501.72, J501.77, J501.78, J501.83, J501.84, J501.93, J501.94, J501.99, J501.100, J501.103, J501.104, J501.105, J501.106, J501.113, J501.114, J501.119, J501.120, J501.125, J501.126, J501.131, J501.132, J501.137, J501.138, J501.143, J501.144, J501.149, J501.150, J502.1, J502.2, J502.7, J502.8, J502.13, J502.14, J502.19, J502.20, J502.25, J502.26, J502.31, J502.32, J502.37, J502.38, J502.43, J502.44, J502.49, J502.50, J502.55, J502.56, J502.61, J502.62, J502.67, J502.68, J502.73, J502.74, J502.79, J502.80, J502.85, J502.86, J502.91, J502.92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; also elsewhere on the board
GPIO14_nErr4: J501.55; also elsewhere on the board
GPIO15_Err1: J501.48; also elsewhere on the board
GPIO20_nErr1: J501.47; also elsewhere on the board
GPIO21_nErr2: J501.49; also elsewhere on the board
GPIO33: J501.57; also elsewhere on the board
GPIO34: J501.58; also elsewhere on the board
GPIO40: J502.132; also elsewhere on the board
GPIO41: J502.120; also elsewhere on the board
GPIO44: J502.119; also elsewhere on the board
GPIO45: J502.118; also elsewhere on the board
GPIO49: J502.135; also elsewhere on the board
GPIO50: J502.136; also elsewhere on the board
GPIO51: J502.131; also elsewhere on the board
GPIO52: J502.129; also elsewhere on the board
GPIO53: J502.130; also elsewhere on the board
GPIO95_Err2: J501.50; also elsewhere on the board
GPIO96_Err4: J501.56; also elsewhere on the board
GPIO99_Err3: J501.52; also elsewhere on the board
GPIO104_nErr3: J501.51; also elsewhere on the board
I2CA_SCL|GPIO1: J501.21; also elsewhere on the board
I2CA_SDA|GPIO0: J501.22; also elsewhere on the board
MCAN_RX|GPIO70: J501.17; also elsewhere on the board
MCAN_TX|GPIO4: J501.18; also elsewhere on the board
P0_CLK_25MHz: J502.148; also elsewhere on the board
P1_CLK_25MHz: J502.147; also elsewhere on the board
SCIB_RX|GPIO23: J501.46; also elsewhere on the board
SCIB_TX|GPIO22: J501.45; also elsewhere on the board
SCIC_RX|GPIO13: J501.24; also elsewhere on the board
SCIC_TX|GPIO12: J501.23; also elsewhere on the board
SPIA_CLK|GPIO18: J501.30; also elsewhere on the board
SPIA_MISO|GPIO17: J501.28; also elsewhere on the board
SPIA_MOSI|GPIO16: J501.27; also elsewhere on the board
SPIA_STEn|GPIO19: J501.29; also elsewhere on the board
SPIB_CLK|GPIO26: J501.42; also elsewhere on the board
SPIB_MISO|GPIO25: J501.40; also elsewhere on the board
SPIB_MOSI|GPIO24: J501.39; also elsewhere on the board
SPIB_STEn|GPIO27: J501.41; also elsewhere on the board
SPIC_CLK|GPIO102: J501.36; also elsewhere on the board
SPIC_MISO|GPIO101: J501.34; also elsewhere on the board
SPIC_MOSI|GPIO100: J501.33; also elsewhere on the board
SPIC_STEn|GPIO103: J501.35; also elsewhere on the board
SSIA_CLK|GPIO56: J502.124; also elsewhere on the board
SSIA_FSS|GPIO57: J502.123; also elsewhere on the board
SSIA_RX|GPIO55: J502.125; also elsewhere on the board
SSIA_TX|GPIO54: J502.126; also elsewhere on the board
UARTA_RX|GPIO43: J502.52; also elsewhere on the board
UARTA_TX|GPIO42: J502.51; also elsewhere on the board
nErr_AND_output: J501.16; also elsewhere on the board

Notes on the sheet:
Bottom J502 Connector
Bottom J501 Connector

Board: 8 copper layers, 85.0 x 55.0 mm, 266 parts (105 on the bottom side), 330 nets.

## KiCad design LCB-ADA-01/LCB-ADA-01.kicad_pcb

Parts:
C1, C2: C_0402_100n_X7R_10P__50V; C_0402; mouser# 810-C1005X7R1H104K
U1: ADAPTER_OP_SOIC_16; ADAPTER_Soic16
U2, U3: OP_2_TLV7012_WSON8; WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; mouser# 595-TLV7012DSGR

Connections:
+3V3: C1.1, C2.1, U1.12 (VCC), U1.16 (VCC), U2.8 (VCC), U3.8 (VCC)
/OP1_NEG: U1.2 (OP1_NEG), U2.2 (-)
/OP1_OUT: U1.15 (OP1_OUT), U2.1
/OP1_POS: U1.1 (OP1_POS), U2.3 (+)
/OP2_NEG: U1.4 (OP2_NEG), U2.6 (-)
/OP2_OUT: U1.14 (OP2_OUT), U2.7
/OP2_POS: U1.3 (OP2_POS), U2.5 (+)
/OP3_NEG: U1.6 (OP3_NEG), U3.2 (-)
/OP3_OUT: U1.11 (OP3_OUT), U3.1
/OP3_POS: U1.5 (OP3_POS), U3.3 (+)
/OP4_NEG: U1.8 (OP4_NEG), U3.6 (-)
/OP4_OUT: U1.10 (OP4_OUT), U3.7
/OP4_POS: U1.7 (OP4_POS), U3.5 (+)
GND: C1.2, C2.2, U1.9 (GND), U1.13 (GND), U2.4 (GND), U3.4 (GND)

Board: 2 copper layers, 5.6 x 10.5 mm, 5 parts (0 on the bottom side), 14 nets.

## KiCad design hardware/02_Extension_boards/LCB-CHW-001_Hardware_Monitor/Hardware_Monitor.kicad_pcb

Board: 2 copper layers, 60.0 x 70.0 mm, 47 parts (0 on the bottom side), 21 nets.

Parts:
C201, C202, C203, C204: 1n/50V; C_0603
C301, C303, C306, C308: 2.2u/25V; C_0603
C302, C304, C305, C307, C402: 100n/50V; C_0603
C401: 10µ/16V; C_0603
D301, D302: LED_APTD1608LCGCK; LED_0603
H201, H202, H203, H204: M3; MountingHole_M3
J201, J202, J203, J204: Molex_731000207; SMB_Molex731000207
J301: Molex_532617006; 6-PinHeader_Molex_532617006
R201, R202, R205, R206: 10K; R_0603
R203, R204, R207, R208: 100R; R_0603
R301, R302, R303: 680R; R_0603
TP201, TP202, TP203, TP204, TP205, TP206, TP207, TP208: Keystone_Electronics_5019; TestPoint_KeystoneElectronics5019
U301: MEJ1S0305SC; SIP-7_Murata_MEJ1S0305SC
U302: ISO7741FQDWWQ1; SOIC-16_TI_DWW0016A_Optimized
U401: AD5664BRMZ; MSOP-10_AnalogDevices_RM10

Connections:
+3.3V_HV: C301.1, C302.1, C303.1, C304.1, D301.A, J301.1, U301.1 (V_in+), U302.1 (VCC1)
+5V_LV: C305.1, C306.1, C307.1, C308.1, C401.1, C402.1, D302.A, U301.7 (V_out+), U302.10 (EN2), U302.16 (VCC2), U401.9 (VDD), U401.10 (Vref)
/Output Ports/A_Out: C201.1, J201.1, R203.1, TP201.1 (TP)
/Output Ports/B_Out: C202.1, J202.1, R204.1, TP203.1 (TP)
/Output Ports/C_Out: C203.1, J203.1, R207.1, TP205.1 (TP)
/Output Ports/D_Out: C204.1, J204.1, R208.1, TP207.1 (TP)
CH_A: R201.2, R203.2, U401.1 (V_outA)
CH_B: R202.2, R204.2, U401.2 (V_outB)
CH_C: R205.2, R207.2, U401.4 (V_outC)
CH_D: R206.2, R208.2, U401.5 (V_outD)
GND_HV: C301.2, C302.2, C303.2, C304.2, J301.6, R301.2, U301.2 (V_in-), U302.2 (GND1), U302.7 (EN1), U302.8 (GND1)
GND_LV: C201.2, C202.2, C203.2, C204.2, C305.2, C306.2, C307.2, C308.2, C401.2, C402.2, J201.2, J202.2, J203.2, J204.2, R201.1, R202.1, R205.1, R206.1, R303.2, TP202.1 (TP), TP204.1 (TP), TP206.1 (TP), TP208.1 (TP), U301.5 (V_out-), U302.9 (GND2), U302.11 (IND), U302.15 (GND2), U401.3 (GND)
unnamed: D301.C, R301.1
unnamed: D302.C, R302.1
unnamed: R302.2, R303.1
SPI_CLK: J301.2, U302.3 (INA)
SPI_CLK_scope: U302.14 (OUTA), U401.7 (SCK)
SPI_CS: J301.5, U302.5 (INC)
SPI_CS_scope: U302.12 (OUTC), U401.6 (~SYNC)
SPI_MOSI: J301.3, U302.4 (INB)
SPI_MOSI_scope: U302.13 (OUTB), U401.8 (DIN)
